* NGSPICE file created from semi_cpu_top.ext - technology: sky130A

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_2 abstract view
.subckt sky130_fd_sc_hd__a311oi_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32ai_4 abstract view
.subckt sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_12 abstract view
.subckt sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_4 abstract view
.subckt sky130_fd_sc_hd__a22o_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_2 abstract view
.subckt sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

.subckt semi_cpu_top Result[0] Result[10] Result[11] Result[12] Result[13] Result[14]
+ Result[15] Result[16] Result[17] Result[18] Result[19] Result[1] Result[20] Result[21]
+ Result[22] Result[23] Result[24] Result[25] Result[26] Result[27] Result[28] Result[29]
+ Result[2] Result[30] Result[31] Result[3] Result[4] Result[5] Result[6] Result[7]
+ Result[8] Result[9] VGND VPWR alu_op_tb[0] alu_op_tb[1] alu_op_tb[2] an[0] an[1]
+ an[2] an[3] clk control immediate_tb[0] immediate_tb[10] immediate_tb[12] immediate_tb[13]
+ immediate_tb[14] immediate_tb[15] immediate_tb[16] immediate_tb[17] immediate_tb[18]
+ immediate_tb[19] immediate_tb[1] immediate_tb[20] immediate_tb[21] immediate_tb[22]
+ immediate_tb[23] immediate_tb[24] immediate_tb[25] immediate_tb[26] immediate_tb[2]
+ immediate_tb[30] immediate_tb[31] immediate_tb[3] immediate_tb[4] immediate_tb[5]
+ immediate_tb[6] immediate_tb[7] immediate_tb[8] immediate_tb[9] instruction_tb[0]
+ instruction_tb[10] instruction_tb[11] instruction_tb[12] instruction_tb[13] instruction_tb[14]
+ instruction_tb[15] instruction_tb[16] instruction_tb[17] instruction_tb[18] instruction_tb[19]
+ instruction_tb[1] instruction_tb[20] instruction_tb[21] instruction_tb[22] instruction_tb[23]
+ instruction_tb[24] instruction_tb[25] instruction_tb[26] instruction_tb[27] instruction_tb[28]
+ instruction_tb[29] instruction_tb[2] instruction_tb[30] instruction_tb[31] instruction_tb[3]
+ pc_out_tb[0] pc_out_tb[1] pc_out_tb[2] rd1_tb[0] rd1_tb[10] rd1_tb[11] rd1_tb[12]
+ rd1_tb[13] rd1_tb[14] rd1_tb[15] rd1_tb[16] rd1_tb[17] rd1_tb[18] rd1_tb[19] rd1_tb[1]
+ rd1_tb[20] rd1_tb[21] rd1_tb[22] rd1_tb[23] rd1_tb[24] rd1_tb[25] rd1_tb[26] rd1_tb[27]
+ rd1_tb[28] rd1_tb[29] rd1_tb[2] rd1_tb[30] rd1_tb[31] rd1_tb[3] rd1_tb[4] rd1_tb[5]
+ rd1_tb[6] rd1_tb[7] rd1_tb[8] rd1_tb[9] rd2_tb[0] rd2_tb[10] rd2_tb[11] rd2_tb[12]
+ rd2_tb[13] rd2_tb[14] rd2_tb[15] rd2_tb[16] rd2_tb[17] rd2_tb[18] rd2_tb[19] rd2_tb[1]
+ rd2_tb[20] rd2_tb[21] rd2_tb[22] rd2_tb[23] rd2_tb[24] rd2_tb[25] rd2_tb[26] rd2_tb[27]
+ rd2_tb[28] rd2_tb[29] rd2_tb[2] rd2_tb[30] rd2_tb[31] rd2_tb[3] rd2_tb[4] rd2_tb[5]
+ rd2_tb[6] rd2_tb[7] rd2_tb[8] rd2_tb[9] rst seg[0] seg[1] seg[2] seg[3] seg[4] seg[5]
+ seg[6] instruction_tb[6] instruction_tb[5] instruction_tb[4] immediate_tb[29] immediate_tb[28]
+ immediate_tb[27] instruction_tb[9] immediate_tb[11] instruction_tb[8] instruction_tb[7]
XFILLER_0_27_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2106_ _0683_ _0702_ _0733_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__o21a_1
X_2037_ _0879_ _0882_ _0806_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2365__A _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1748__A2 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer7 _0519_ VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_11_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2724_ clknet_4_13_0_clk _0302_ _0118_ VGND VGND VPWR VPWR rf.registers\[25\]\[29\]
+ sky130_fd_sc_hd__dfrtp_1
X_2655_ clknet_4_11_0_clk _0233_ VGND VGND VPWR VPWR ssdc.clk_divider\[12\] sky130_fd_sc_hd__dfxtp_1
X_1606_ _0547_ _0549_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__and2_1
X_2586_ _1266_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__inv_2
X_1537_ _0499_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_2
X_1468_ _0457_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__clkbuf_1
X_1399_ net334 _0415_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_78_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_0_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1711__B net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2672__CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2091__A1 _0787_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2440_ _1242_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__inv_2
XFILLER_0_59_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2371_ _1194_ _1184_ _1196_ _1197_ _1191_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__a32o_1
X_1322_ _0377_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_18_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2707_ clknet_4_3_0_clk _0285_ _0101_ VGND VGND VPWR VPWR rf.registers\[25\]\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_71_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2638_ _1273_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__inv_2
X_2569_ _1264_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1940_ net84 _0796_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1871_ _0780_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_54_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2423_ _1214_ _1229_ _1231_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__and3_1
X_2354_ _1181_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_63_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1305_ net244 _0367_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__and2_1
X_2285_ _1152_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_66_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1807__A net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2294__A1 _1033_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2710__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2046__A1 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1452__A _0437_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_3_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2070_ _0970_ _0971_ _0832_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2283__A _0400_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1923_ _0834_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1796__B1 net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1854_ rf.registers\[25\]\[29\] net140 _0483_ rf.registers\[10\]\[29\] VGND VGND
+ VPWR VPWR _0772_ sky130_fd_sc_hd__a22o_1
XFILLER_0_24_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1785_ _0709_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__buf_2
X_2406_ net223 _1218_ _1214_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_4_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2337_ net142 _0392_ _1144_ VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__o21a_1
XFILLER_0_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2268_ net323 _1142_ _0483_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_83_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2199_ rf.registers\[25\]\[13\] _1086_ _1087_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__mux2_1
XANTENNA__2028__A1 _0790_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2132__S _1016_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold30 ssdc.clk_divider\[2\] VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 ssdc.clk_divider\[4\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 rf.registers\[5\]\[5\] VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 rf.registers\[15\]\[6\] VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold52 net10 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__2267__A1 _1025_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold85 rf.registers\[15\]\[31\] VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__dlygate4sd3_1
Xhold96 rf.registers\[25\]\[5\] VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1570_ rf.registers\[15\]\[1\] _0476_ _0486_ rf.registers\[5\]\[1\] VGND VGND VPWR
+ VPWR _0518_ sky130_fd_sc_hd__a22oi_4
XANTENNA__2042__S net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output86_A net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2122_ _0896_ _0932_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2053_ _0750_ _0956_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__or2b_1
XFILLER_0_88_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2353__S1 ssdc.digit_select\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1769__B1 _0481_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1906_ net95 _0798_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__nand2_1
X_1837_ net85 _0754_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1768_ _0689_ _0694_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__or2b_1
XFILLER_0_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1699_ _0632_ VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_67_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1966__S _0578_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput20 net20 VGND VGND VPWR VPWR Result[26] sky130_fd_sc_hd__buf_2
Xoutput42 net42 VGND VGND VPWR VPWR immediate_tb[1] sky130_fd_sc_hd__buf_2
Xoutput31 net31 VGND VGND VPWR VPWR Result[7] sky130_fd_sc_hd__buf_2
Xoutput7 net7 VGND VGND VPWR VPWR Result[14] sky130_fd_sc_hd__buf_2
Xoutput53 net53 VGND VGND VPWR VPWR instruction_tb[22] sky130_fd_sc_hd__buf_2
Xoutput64 net64 VGND VGND VPWR VPWR instruction_tb[3] sky130_fd_sc_hd__buf_2
Xoutput75 net75 VGND VGND VPWR VPWR rd1_tb[16] sky130_fd_sc_hd__buf_2
Xoutput97 net97 VGND VGND VPWR VPWR rd1_tb[7] sky130_fd_sc_hd__buf_2
Xoutput86 net86 VGND VGND VPWR VPWR rd1_tb[26] sky130_fd_sc_hd__buf_2
XANTENNA__2098__A _0631_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1730__A net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2740_ clknet_4_4_0_clk _0318_ _0134_ VGND VGND VPWR VPWR rf.registers\[15\]\[13\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA__2561__A _1264_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2671_ clknet_4_7_0_clk _0249_ _0065_ VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1622_ _0561_ _0564_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__nor2_1
X_1553_ net107 net110 VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1484_ _0465_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__clkbuf_1
X_2105_ _1004_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__clkbuf_1
X_2036_ _0939_ _0940_ _0876_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2365__B _1183_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2642__B2 ssdc.digit_select\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer8 net189 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA__1725__A net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2723_ clknet_4_15_0_clk _0301_ _0117_ VGND VGND VPWR VPWR rf.registers\[25\]\[28\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_81_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2654_ clknet_4_10_0_clk _0232_ VGND VGND VPWR VPWR ssdc.clk_divider\[11\] sky130_fd_sc_hd__dfxtp_1
X_1605_ _0547_ _0549_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__nor2_1
X_2585_ _1266_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1536_ rf.registers\[15\]\[20\] _0478_ _0488_ rf.registers\[5\]\[20\] VGND VGND VPWR
+ VPWR _0499_ sky130_fd_sc_hd__a22o_1
X_1467_ rf.registers\[15\]\[14\] _0449_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__and2_1
Xfanout139 net52 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__buf_4
X_1398_ _0421_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_78_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2019_ _0923_ _0924_ net122 VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2370_ _1186_ _1182_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__and2b_1
X_1321_ net264 _0367_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__and2_1
XFILLER_0_75_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2706_ clknet_4_3_0_clk _0284_ _0100_ VGND VGND VPWR VPWR rf.registers\[25\]\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2637_ _1268_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1365__A _0403_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2568_ _1264_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__inv_2
XFILLER_0_49_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1519_ rf.registers\[15\]\[29\] _0480_ _0490_ rf.registers\[5\]\[29\] VGND VGND VPWR
+ VPWR net121 sky130_fd_sc_hd__a22o_1
X_2499_ _1257_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__inv_2
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1870_ net92 _0784_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2422_ _1230_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__inv_2
X_2353_ net2 net28 net32 net5 ssdc.digit_select\[0\] ssdc.digit_select\[1\] VGND VGND
+ VPWR VPWR _1181_ sky130_fd_sc_hd__mux4_2
X_1304_ _0368_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2284_ net19 _0992_ _1151_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1999_ net125 _0896_ _0900_ _0905_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_30_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1823__A net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_72_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2564__A _1264_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1922_ net81 net80 _0804_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1853_ _0764_ _0740_ _0770_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1784_ rf.registers\[25\]\[21\] _0474_ _0482_ rf.registers\[10\]\[21\] VGND VGND
+ VPWR VPWR _0709_ sky130_fd_sc_hd__a22o_1
XFILLER_0_24_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2405_ _1218_ _1219_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_4_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2336_ _1178_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__clkbuf_1
X_2267_ _1025_ _1000_ _1141_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2198_ _0483_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_35_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold31 _1217_ VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 ssdc.clk_divider\[16\] VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 rf.registers\[5\]\[10\] VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 rf.registers\[25\]\[11\] VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 rf.registers\[5\]\[22\] VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 rf.registers\[10\]\[6\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold97 rf.registers\[10\]\[20\] VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_85_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2121_ net125 _0790_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2052_ _0766_ _0955_ _0765_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_88_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1910__B _0795_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1905_ _0817_ _0818_ _0804_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1836_ net85 _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__nand2_1
X_1767_ net77 _0693_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__xor2_1
X_1698_ _0392_ _0631_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__and2_1
XFILLER_0_40_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2700__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2319_ net32 _1108_ _1162_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput21 net21 VGND VGND VPWR VPWR Result[27] sky130_fd_sc_hd__buf_2
Xoutput43 net43 VGND VGND VPWR VPWR immediate_tb[2] sky130_fd_sc_hd__buf_2
Xoutput32 net32 VGND VGND VPWR VPWR Result[8] sky130_fd_sc_hd__buf_2
Xoutput8 net8 VGND VGND VPWR VPWR Result[15] sky130_fd_sc_hd__buf_2
Xoutput10 net10 VGND VGND VPWR VPWR Result[17] sky130_fd_sc_hd__buf_2
Xoutput54 net140 VGND VGND VPWR VPWR instruction_tb[23] sky130_fd_sc_hd__buf_2
Xoutput65 net142 VGND VGND VPWR VPWR pc_out_tb[0] sky130_fd_sc_hd__clkbuf_4
Xoutput76 net76 VGND VGND VPWR VPWR rd1_tb[17] sky130_fd_sc_hd__buf_2
Xoutput98 net98 VGND VGND VPWR VPWR rd1_tb[8] sky130_fd_sc_hd__buf_2
Xoutput87 net87 VGND VGND VPWR VPWR rd1_tb[27] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_59_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2670_ clknet_4_7_0_clk _0248_ _0064_ VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__dfrtp_1
X_1621_ _0541_ _0563_ _0393_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1552_ rf.registers\[15\]\[19\] _0478_ _0488_ rf.registers\[5\]\[19\] VGND VGND VPWR
+ VPWR net110 sky130_fd_sc_hd__a22o_1
XFILLER_0_1_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1483_ net256 _0437_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1687__B1 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2104_ net299 _1003_ net52 VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__mux2_1
X_2035_ _0873_ _0878_ _0806_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2799_ clknet_4_1_0_clk _0192_ _0030_ VGND VGND VPWR VPWR rf.registers\[5\]\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_1819_ rf.registers\[25\]\[27\] net140 _0482_ rf.registers\[10\]\[27\] VGND VGND
+ VPWR VPWR _0741_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2138__S _1016_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer9 net190 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_31_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2572__A _1265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2722_ clknet_4_12_0_clk _0300_ _0116_ VGND VGND VPWR VPWR rf.registers\[25\]\[27\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_54_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2653_ clknet_4_11_0_clk _0231_ VGND VGND VPWR VPWR ssdc.clk_divider\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1604_ _0542_ _0548_ net60 VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__a21oi_1
X_2584_ _1266_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__inv_2
X_1535_ _0498_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__buf_1
XFILLER_0_22_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1466_ _0456_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2321__A1 _1112_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1397_ rf.registers\[10\]\[16\] _0415_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_78_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2018_ _0801_ _0843_ _0855_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold150 net14 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__2376__B _1183_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2331__S _0400_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1320_ _0376_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output61_A net61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2567__A _1264_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2705_ clknet_4_2_0_clk _0283_ _0099_ VGND VGND VPWR VPWR rf.registers\[25\]\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2636_ _1272_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2567_ _1264_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__inv_2
XFILLER_0_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1518_ _0488_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__clkbuf_4
X_2498_ _1257_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__inv_2
XFILLER_0_49_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1449_ _0447_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2387__A ssdc.digit_select\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1639__A3 _0578_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2421_ ssdc.clk_divider\[9\] _1226_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__and2_1
X_2352_ _0577_ VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__inv_2
X_1303_ rf.registers\[5\]\[21\] _0367_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__and2_1
X_2283_ _0400_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_79_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1998_ _0848_ _0834_ _0904_ _0832_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2619_ _1271_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__inv_2
XANTENNA__2279__A0 net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2000__A _0860_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1733__B net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkload6_A clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__2056__S _0815_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1921_ _0796_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__buf_2
XFILLER_0_56_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1852_ _0751_ _0767_ _0768_ _0769_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__a211o_1
XANTENNA__2580__A _1265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1783_ _0706_ _0707_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__nand2_1
X_2404_ net222 _1216_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__nor2_1
XANTENNA__1924__A net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2335_ net2 _1142_ _0400_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__mux2_1
X_2266_ _0594_ _1140_ _0787_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__a21o_1
X_2197_ _0862_ _0922_ _1085_ net62 VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2490__A _1255_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold32 ssdc.clk_divider\[11\] VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 ssdc.clk_divider\[12\] VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 rf.registers\[5\]\[28\] VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 rf.registers\[5\]\[11\] VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__dlygate4sd3_1
Xhold76 rf.registers\[5\]\[13\] VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 net9 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold87 rf.registers\[10\]\[26\] VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__2384__B ssdc.digit_select\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2120_ _0712_ _1007_ _0724_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__a21o_1
X_2051_ _0740_ _0763_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__nand2_1
XANTENNA__2575__A _1265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1904_ net96 _0798_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1769__A2 _0474_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1835_ _0542_ _0753_ _0396_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1766_ _0542_ _0692_ _0395_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1697_ _0630_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__inv_2
X_2318_ _1169_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2249_ _0588_ _0598_ _0599_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__and3_1
XFILLER_0_73_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_16_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput22 net22 VGND VGND VPWR VPWR Result[28] sky130_fd_sc_hd__buf_2
Xoutput33 net33 VGND VGND VPWR VPWR Result[9] sky130_fd_sc_hd__buf_2
Xoutput9 net9 VGND VGND VPWR VPWR Result[16] sky130_fd_sc_hd__buf_2
Xoutput11 net11 VGND VGND VPWR VPWR Result[18] sky130_fd_sc_hd__buf_2
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput55 net55 VGND VGND VPWR VPWR instruction_tb[24] sky130_fd_sc_hd__buf_2
Xoutput66 net66 VGND VGND VPWR VPWR pc_out_tb[1] sky130_fd_sc_hd__buf_2
Xoutput44 net44 VGND VGND VPWR VPWR immediate_tb[3] sky130_fd_sc_hd__buf_2
Xoutput99 net99 VGND VGND VPWR VPWR rd1_tb[9] sky130_fd_sc_hd__buf_2
Xoutput77 net77 VGND VGND VPWR VPWR rd1_tb[18] sky130_fd_sc_hd__buf_2
Xoutput88 net88 VGND VGND VPWR VPWR rd1_tb[28] sky130_fd_sc_hd__buf_2
XANTENNA__2675__CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1739__A net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1620_ net128 _0562_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__xor2_1
XANTENNA_output91_A net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1551_ _0506_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__clkbuf_2
X_1482_ _0464_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__1687__A1 _0393_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2103_ _0862_ _0996_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__o21ai_1
X_2034_ _0869_ _0872_ _0806_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1818_ _0726_ _0702_ _0683_ _0739_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_32_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2798_ clknet_4_1_0_clk _0191_ _0029_ VGND VGND VPWR VPWR rf.registers\[5\]\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1749_ net107 _0610_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1850__A1 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2154__S _1016_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1278__B net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2329__S _0400_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2064__S net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2721_ clknet_4_15_0_clk _0299_ _0115_ VGND VGND VPWR VPWR rf.registers\[25\]\[26\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_81_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2652_ clknet_4_11_0_clk _0230_ VGND VGND VPWR VPWR ssdc.clk_divider\[9\] sky130_fd_sc_hd__dfxtp_1
X_1603_ net120 _0532_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__xnor2_1
X_2583_ _1266_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__inv_2
X_1534_ rf.registers\[15\]\[21\] _0478_ _0488_ rf.registers\[5\]\[21\] VGND VGND VPWR
+ VPWR _0498_ sky130_fd_sc_hd__a22o_1
X_1465_ rf.registers\[15\]\[15\] _0449_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__and2_1
X_1396_ _0420_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_78_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2017_ _0836_ _0845_ net111 VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold151 rf.registers\[10\]\[8\] VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
Xhold140 net11 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_68_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1988__S _0840_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1752__A _0677_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output54_A net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2704_ clknet_4_3_0_clk _0282_ _0098_ VGND VGND VPWR VPWR rf.registers\[25\]\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_40_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2635_ _1272_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2566_ _1264_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1517_ _0489_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_1
XFILLER_0_10_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2497_ _1255_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__buf_4
XFILLER_0_10_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1448_ net274 _0438_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1379_ _0411_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_38_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1837__A net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2230__A1 _1112_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2420_ ssdc.clk_divider\[9\] _1226_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2351_ _1180_ VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
XANTENNA__2578__A _1265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1302_ _0355_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__clkbuf_2
X_2282_ _1150_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2288__A1 _1015_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_32_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1997_ net111 _0901_ _0902_ _0903_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__a211o_1
XANTENNA__2252__S _0483_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_41_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2618_ _1271_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__inv_2
X_2549_ _1260_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_86_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1920_ _0832_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1851_ net87 _0743_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1782_ _0703_ _0705_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2403_ ssdc.clk_divider\[3\] _1216_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__and2_1
X_2334_ _1177_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__1705__B1 _0480_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2265_ net100 net61 net68 VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__or3b_1
XANTENNA__1940__A net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2196_ _1083_ _1084_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_83_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold33 _1234_ VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 ssdc.clk_divider\[10\] VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 rf.registers\[15\]\[30\] VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 rf.registers\[5\]\[25\] VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 rf.registers\[5\]\[6\] VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 rf.registers\[15\]\[27\] VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 rf.registers\[25\]\[6\] VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2050_ _0954_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2112__B1 _0630_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1903_ net97 _0795_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1834_ net117 _0530_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__xnor2_1
X_1765_ net109 _0691_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1696_ _0538_ net1 _0354_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__a21oi_4
X_2317_ net33 _1103_ _1162_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__mux2_1
X_2248_ _1127_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2179_ _1063_ _1069_ _0643_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__a21o_1
XFILLER_0_73_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1829__B net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput23 net23 VGND VGND VPWR VPWR Result[29] sky130_fd_sc_hd__buf_2
Xoutput34 net34 VGND VGND VPWR VPWR alu_op_tb[0] sky130_fd_sc_hd__buf_2
Xoutput12 net12 VGND VGND VPWR VPWR Result[19] sky130_fd_sc_hd__buf_2
Xoutput56 net56 VGND VGND VPWR VPWR instruction_tb[25] sky130_fd_sc_hd__buf_2
Xoutput45 net45 VGND VGND VPWR VPWR instruction_tb[0] sky130_fd_sc_hd__buf_2
Xoutput67 net141 VGND VGND VPWR VPWR pc_out_tb[2] sky130_fd_sc_hd__buf_2
Xoutput78 net78 VGND VGND VPWR VPWR rd1_tb[19] sky130_fd_sc_hd__buf_2
Xoutput89 net89 VGND VGND VPWR VPWR rd1_tb[29] sky130_fd_sc_hd__buf_2
XANTENNA__1696__A2 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1550_ rf.registers\[15\]\[16\] _0478_ _0487_ rf.registers\[5\]\[16\] VGND VGND VPWR
+ VPWR _0506_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output84_A net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1481_ net241 _0437_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__and2_1
X_2102_ _0997_ _0998_ _1001_ _0790_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__o22a_1
X_2033_ _0630_ _0912_ _0937_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__or3_1
XFILLER_0_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1817_ _0726_ _0733_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_32_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2797_ clknet_4_1_0_clk _0190_ _0028_ VGND VGND VPWR VPWR rf.registers\[5\]\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1748_ rf.registers\[25\]\[16\] net140 _0482_ rf.registers\[10\]\[16\] VGND VGND
+ VPWR VPWR _0677_ sky130_fd_sc_hd__a22oi_4
X_1679_ _0614_ _0610_ _0556_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_40_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_79_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output122_A net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_88_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1841__A2 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2720_ clknet_4_15_0_clk _0298_ _0114_ VGND VGND VPWR VPWR rf.registers\[25\]\[25\]
+ sky130_fd_sc_hd__dfrtp_1
X_2651_ clknet_4_10_0_clk _0229_ VGND VGND VPWR VPWR ssdc.clk_divider\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1602_ net88 VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__inv_2
X_2582_ _1260_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__buf_4
X_1533_ _0497_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1464_ _0455_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1395_ net232 _0415_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_78_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2016_ _0918_ _0921_ _0832_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_25_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1832__A2 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2665__CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold141 rf.registers\[25\]\[0\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
Xhold152 rf.registers\[10\]\[15\] VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold130 rf.registers\[25\]\[27\] VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_68_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2703_ clknet_4_3_0_clk _0281_ _0097_ VGND VGND VPWR VPWR rf.registers\[25\]\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2634_ _1272_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__inv_2
XFILLER_0_30_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2565_ _1264_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__inv_2
X_1516_ rf.registers\[15\]\[30\] _0479_ _0488_ rf.registers\[5\]\[30\] VGND VGND VPWR
+ VPWR _0489_ sky130_fd_sc_hd__a22o_1
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1943__A net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2496_ _1256_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__inv_2
X_1447_ _0446_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1378_ net315 _0404_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_38_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2014__A net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2350_ _0392_ net62 VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__and2_1
X_1301_ _0366_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__clkbuf_1
X_2281_ net20 _0979_ _1144_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_35_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1996_ net91 _0840_ _0800_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_43_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2617_ _1271_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__inv_2
XANTENNA__2703__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2548_ _1262_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__inv_2
X_2479_ _1253_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__inv_2
XFILLER_0_65_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload0 clknet_4_0_0_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__clkinv_2
XFILLER_0_33_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1650__B1 _0478_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1850_ net87 _0743_ _0748_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_71_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1477__B _0437_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1781_ _0703_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_40_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1953__A1 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2402_ _1216_ net213 VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__nor2_1
XANTENNA__1999__A1_N net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2333_ net13 _1138_ _0400_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2264_ _0539_ VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__inv_2
XFILLER_0_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2195_ _0673_ _1071_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__and2b_1
XFILLER_0_46_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2130__A1 _1025_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1668__A net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1387__B _0415_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2197__B2 net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1979_ net78 net80 _0800_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold45 ssdc.clk_divider\[7\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 ssdc.clk_divider\[5\] VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 rf.registers\[5\]\[17\] VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold89 rf.registers\[15\]\[19\] VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 rf.registers\[5\]\[30\] VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 rf.registers\[10\]\[19\] VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1632__B1 _0393_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2202__A net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1902_ _0807_ _0814_ _0815_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1833_ _0752_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__buf_2
X_1764_ net108 net107 _0528_ _0609_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__or4_1
XFILLER_0_12_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1695_ rf.registers\[25\]\[13\] _0474_ _0481_ rf.registers\[10\]\[13\] VGND VGND
+ VPWR VPWR _0629_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_40_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_4_9_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1951__A _0860_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2316_ _1168_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__clkbuf_1
X_2247_ net292 _1126_ _1087_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2178_ _1064_ _1068_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__or2_1
XFILLER_0_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput24 net24 VGND VGND VPWR VPWR Result[2] sky130_fd_sc_hd__buf_2
XFILLER_0_3_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput13 net13 VGND VGND VPWR VPWR Result[1] sky130_fd_sc_hd__buf_2
XFILLER_0_31_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput46 net46 VGND VGND VPWR VPWR instruction_tb[14] sky130_fd_sc_hd__buf_2
Xoutput35 net35 VGND VGND VPWR VPWR alu_op_tb[1] sky130_fd_sc_hd__buf_2
Xoutput57 net57 VGND VGND VPWR VPWR instruction_tb[26] sky130_fd_sc_hd__buf_2
Xoutput79 net79 VGND VGND VPWR VPWR rd1_tb[1] sky130_fd_sc_hd__buf_2
Xoutput68 net68 VGND VGND VPWR VPWR rd1_tb[0] sky130_fd_sc_hd__buf_2
XANTENNA__2168__S _1016_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1480_ _0463_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__clkbuf_1
XANTENNA_output77_A net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2333__A1 _1138_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2101_ _0999_ _1000_ net125 VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__mux2_1
XANTENNA__2078__S net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2032_ _0553_ _0771_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1816_ _0712_ _0725_ _0734_ _0737_ _0720_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2796_ clknet_4_1_0_clk _0189_ _0027_ VGND VGND VPWR VPWR rf.registers\[5\]\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_4_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1747_ _0665_ _0671_ _0672_ _0675_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__o211a_1
XFILLER_0_40_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1678_ net105 _0611_ _0613_ net106 VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2315__A1 _1099_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2650_ clknet_4_11_0_clk _0228_ VGND VGND VPWR VPWR ssdc.clk_divider\[7\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__1485__B _0437_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1601_ rf.registers\[25\]\[28\] net140 _0482_ rf.registers\[10\]\[28\] VGND VGND
+ VPWR VPWR net88 sky130_fd_sc_hd__a22o_2
X_2581_ _1265_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__inv_2
X_1532_ rf.registers\[15\]\[22\] _0479_ _0488_ rf.registers\[5\]\[22\] VGND VGND VPWR
+ VPWR _0497_ sky130_fd_sc_hd__a22o_1
X_1463_ net263 _0449_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1394_ _0419_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_78_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2015_ _0919_ _0920_ _0815_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__mux2_2
XFILLER_0_49_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2271__S _1144_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1395__B _0415_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2779_ clknet_4_14_0_clk _0172_ _0010_ VGND VGND VPWR VPWR rf.registers\[10\]\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold120 rf.registers\[5\]\[29\] VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
Xhold142 rf.registers\[25\]\[18\] VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
Xhold131 rf.registers\[25\]\[21\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
Xhold153 rf.registers\[10\]\[30\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1520__A2 _0479_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_75_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2702_ clknet_4_2_0_clk _0280_ _0096_ VGND VGND VPWR VPWR rf.registers\[25\]\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_54_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2633_ _1272_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__inv_2
X_2564_ _1264_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1515_ _0487_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__buf_2
XFILLER_0_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2495_ _1256_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__inv_2
X_1446_ net311 _0438_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__and2_1
XFILLER_0_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1377_ _0410_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_38_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1300_ net268 _0356_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2280_ _1149_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2875__A net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1995_ _0840_ net100 net89 VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_43_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2616_ _1271_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2547_ _1262_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__inv_2
X_2478_ _1253_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__inv_2
XFILLER_0_55_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1429_ _0436_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2359__S0 ssdc.digit_select\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload1 clknet_4_1_0_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__clkinv_2
XFILLER_0_18_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2385__A_N ssdc.digit_select\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1780_ _0556_ _0704_ _0394_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_40_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2401_ ssdc.clk_divider\[0\] ssdc.clk_divider\[1\] net212 VGND VGND VPWR VPWR _1217_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_0_20_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2332_ _1176_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__clkbuf_1
X_2263_ _1139_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__clkbuf_1
X_2194_ _0635_ _0636_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_5_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1978_ _0877_ _0884_ net125 VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold46 ssdc.digit_select\[0\] VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 ssdc.clk_divider\[19\] VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 _1222_ VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold57 rf.registers\[15\]\[13\] VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 rf.registers\[25\]\[8\] VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 rf.registers\[10\]\[27\] VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output22_A net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1901_ _0517_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_29_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1832_ rf.registers\[25\]\[25\] net140 _0482_ rf.registers\[10\]\[25\] VGND VGND
+ VPWR VPWR _0752_ sky130_fd_sc_hd__a22o_1
XFILLER_0_4_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1763_ _0690_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__buf_2
XFILLER_0_12_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1694_ _0625_ _0627_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2315_ net3 _1099_ _1162_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__mux2_1
X_2246_ _1025_ _0943_ _1124_ _1125_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_79_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2177_ _0655_ _1067_ _0669_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_79_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput25 net25 VGND VGND VPWR VPWR Result[30] sky130_fd_sc_hd__buf_2
Xoutput14 net14 VGND VGND VPWR VPWR Result[20] sky130_fd_sc_hd__buf_2
Xoutput58 net58 VGND VGND VPWR VPWR instruction_tb[27] sky130_fd_sc_hd__buf_2
Xoutput47 net47 VGND VGND VPWR VPWR instruction_tb[15] sky130_fd_sc_hd__buf_2
Xoutput36 net36 VGND VGND VPWR VPWR alu_op_tb[2] sky130_fd_sc_hd__buf_2
XFILLER_0_11_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput69 net69 VGND VGND VPWR VPWR rd1_tb[10] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_59_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2100_ _0815_ net111 net100 _0828_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__or4_2
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2031_ _0936_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2094__S net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2795_ clknet_4_0_0_clk _0188_ _0026_ VGND VGND VPWR VPWR rf.registers\[5\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_1815_ _0719_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__or2b_1
X_1746_ _0624_ _0636_ _0674_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__or3_1
XFILLER_0_40_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1677_ _0612_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__buf_8
XFILLER_0_40_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2229_ _0831_ _1025_ _1110_ _1111_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__o22ai_4
XANTENNA__2088__A1 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__2033__A _0630_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1872__A _0630_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1591__B _0392_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2369__B1_N _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_13_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2251__A1 _1025_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1600_ _0545_ _0544_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__nor2_1
X_2580_ _1265_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__inv_2
X_1531_ _0496_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__buf_1
X_1462_ _0454_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_22_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1393_ net255 _0415_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_78_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2014_ net111 _0829_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__or2_1
XFILLER_0_54_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2242__A1 _1122_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold110 rf.registers\[25\]\[4\] VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
X_2778_ clknet_4_14_0_clk _0171_ _0009_ VGND VGND VPWR VPWR rf.registers\[10\]\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold121 rf.registers\[15\]\[22\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
Xhold132 rf.registers\[5\]\[27\] VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
Xhold143 rf.registers\[10\]\[0\] VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
X_1729_ _0542_ _0657_ _0394_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__a21o_1
Xhold154 rf.registers\[10\]\[9\] VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_24_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2224__A1 _0787_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_82_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2701_ clknet_4_2_0_clk _0279_ _0095_ VGND VGND VPWR VPWR rf.registers\[25\]\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_27_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2632_ _1272_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2563_ _1264_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__inv_2
X_1514_ _0486_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__buf_2
XFILLER_0_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2494_ _1256_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__inv_2
X_1445_ _0445_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__clkbuf_1
X_1376_ net269 _0404_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_38_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1726__B1 _0481_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2192__S _1016_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output52_A net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1994_ net88 net87 net100 VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_43_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2615_ _1268_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__buf_4
XFILLER_0_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2381__B1 _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2546_ _1262_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__inv_2
XANTENNA_clkbuf_4_1_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2477_ _1253_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__inv_2
X_1428_ net325 _0426_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__and2_1
XANTENNA__2359__S1 ssdc.digit_select\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2277__S _1144_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1359_ net66 _0390_ _0399_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload2 clknet_4_2_0_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__inv_6
XANTENNA__1947__A0 net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2187__S _1016_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2400_ ssdc.clk_divider\[0\] ssdc.clk_divider\[1\] ssdc.clk_divider\[2\] VGND VGND
+ VPWR VPWR _1216_ sky130_fd_sc_hd__and3_1
X_2331_ net24 _1134_ _0400_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__mux2_1
X_2262_ net329 _1138_ _0483_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__mux2_1
XANTENNA__2772__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2193_ _1082_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1977_ _0881_ _0883_ _0876_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2529_ _1261_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__inv_2
Xhold47 _0348_ VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 ssdc.clk_divider\[13\] VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 _0240_ VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold58 rf.registers\[10\]\[24\] VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 rf.registers\[10\]\[23\] VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__2345__B1 _0392_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_45_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1900_ _0810_ _0813_ _0806_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1831_ _0744_ _0750_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1762_ rf.registers\[25\]\[18\] _0474_ _0482_ rf.registers\[10\]\[18\] VGND VGND
+ VPWR VPWR _0690_ sky130_fd_sc_hd__a22o_1
XFILLER_0_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1693_ _0541_ _0626_ _0393_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_25_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2314_ _1167_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2639__A1 ssdc.digit_select\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2245_ _0602_ net62 VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__nand2_1
X_2176_ _1065_ _0565_ _1066_ _0659_ _0662_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__o311a_1
XFILLER_0_79_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2668__CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput15 net15 VGND VGND VPWR VPWR Result[21] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput37 net37 VGND VGND VPWR VPWR an[0] sky130_fd_sc_hd__clkbuf_4
Xoutput26 net26 VGND VGND VPWR VPWR Result[31] sky130_fd_sc_hd__buf_2
Xoutput48 net48 VGND VGND VPWR VPWR instruction_tb[16] sky130_fd_sc_hd__buf_2
Xoutput59 net59 VGND VGND VPWR VPWR instruction_tb[28] sky130_fd_sc_hd__buf_2
XANTENNA__2342__A3 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2030_ net272 _0935_ net139 VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2794_ clknet_4_0_0_clk _0187_ _0025_ VGND VGND VPWR VPWR rf.registers\[5\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_4_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1814_ _0735_ _0723_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1745_ _0673_ _0635_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1676_ _0526_ _0514_ _0523_ _0503_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__or4_4
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2228_ _0662_ _0559_ _1105_ _0630_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__a31o_1
X_2159_ _0932_ _0988_ _1012_ _0985_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_39_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_48_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1826__A2 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_output82_A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1530_ rf.registers\[15\]\[23\] _0480_ _0490_ rf.registers\[5\]\[23\] VGND VGND VPWR
+ VPWR _0496_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1461_ net275 _0449_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__and2_1
X_1392_ _0418_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_66_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2013_ _0822_ _0826_ _0806_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_75_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1973__A _0840_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold100 rf.registers\[25\]\[7\] VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__2706__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2777_ clknet_4_14_0_clk _0170_ _0008_ VGND VGND VPWR VPWR rf.registers\[10\]\[18\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold111 rf.registers\[15\]\[25\] VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
Xhold122 rf.registers\[15\]\[21\] VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1728_ net130 _0528_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__xnor2_1
Xhold144 rf.registers\[25\]\[26\] VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
Xhold133 rf.registers\[10\]\[25\] VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
Xhold155 rf.registers\[15\]\[3\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
X_1659_ _0592_ _0594_ _0595_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__and3b_1
XPHY_EDGE_ROW_84_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1883__A _0795_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output120_A net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2700_ clknet_4_3_0_clk _0278_ _0094_ VGND VGND VPWR VPWR rf.registers\[25\]\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2631_ _1272_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__inv_2
X_2562_ _1264_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1513_ _0485_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__buf_4
XFILLER_0_50_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2493_ _1256_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__inv_2
X_1444_ net293 _0438_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__and2_1
X_1375_ _0409_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_38_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1671__B1 _0480_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1974__A1 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2829_ clknet_4_11_0_clk _0351_ VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1993_ _0848_ _0899_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2614_ _1270_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2545_ _1262_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__inv_2
XFILLER_0_76_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2476_ _1253_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__inv_2
XFILLER_0_76_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1427_ _0354_ _0398_ net208 VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__a21o_1
X_1358_ _0397_ _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__and2_1
X_1289_ _0360_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1698__A _0392_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1644__B1 _0478_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1947__A1 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkload3 clknet_4_3_0_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_73_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2124__A1 net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1635__B1 _0479_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2330_ _1175_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__clkbuf_1
X_2261_ _1025_ _0985_ _1137_ _0631_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__a2bb2o_2
X_2192_ net305 _1081_ _1016_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1626__B1 _0480_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1976_ _0590_ _0828_ _0882_ net111 VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_28_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2528_ _1261_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__inv_2
Xhold37 _1236_ VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 rf.registers\[10\]\[1\] VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dlygate4sd3_1
X_2459_ _1251_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__inv_2
Xhold59 rf.registers\[15\]\[7\] VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 rf.registers\[5\]\[1\] VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1856__B1 net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2281__A0 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1830_ _0748_ _0749_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1761_ net78 _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__xnor2_1
X_1692_ net103 _0613_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2313_ net4 _1096_ _1162_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__mux2_1
X_2244_ _0583_ _0600_ _0601_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2175_ _0570_ _0575_ _0602_ _0604_ _0606_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__a311oi_2
XFILLER_0_79_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1959_ net127 _0789_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput38 net38 VGND VGND VPWR VPWR an[1] sky130_fd_sc_hd__clkbuf_4
Xoutput16 net16 VGND VGND VPWR VPWR Result[22] sky130_fd_sc_hd__buf_2
Xoutput27 net27 VGND VGND VPWR VPWR Result[3] sky130_fd_sc_hd__buf_2
Xoutput49 net49 VGND VGND VPWR VPWR instruction_tb[17] sky130_fd_sc_hd__buf_2
XANTENNA__1915__S _0578_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2327__A1 _1126_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1550__A2 _0478_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_4_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2793_ clknet_4_0_0_clk _0186_ _0024_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_25_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1813_ net82 VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__inv_2
XFILLER_0_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1744_ _0625_ _0627_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1675_ net104 net103 VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__or2_1
XANTENNA__2309__A1 _1086_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1532__A2 _0479_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2227_ _0662_ _0559_ _1105_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2158_ _1049_ _1050_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2089_ _0848_ _0927_ _0989_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1762__A2 _0474_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1460_ _0453_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__clkbuf_1
XANTENNA_output75_A net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1391_ net249 _0415_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2012_ _0916_ _0917_ _0876_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold101 rf.registers\[15\]\[12\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
X_2776_ clknet_4_14_0_clk _0169_ _0007_ VGND VGND VPWR VPWR rf.registers\[10\]\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_53_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1727_ _0656_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_2
Xhold123 rf.registers\[25\]\[14\] VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
Xhold134 rf.registers\[10\]\[14\] VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
Xhold112 rf.registers\[25\]\[20\] VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlygate4sd3_1
X_1658_ _0537_ _0590_ _0591_ net79 VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__a31o_1
Xhold145 rf.registers\[15\]\[20\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
Xhold156 rf.registers\[10\]\[28\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_69_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1589_ net123 _0533_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2630_ _1272_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_30_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2561_ _1264_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1512_ net141 net1 net142 VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__and3_1
X_2492_ _1256_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__inv_2
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1443_ _0444_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__clkbuf_1
X_1374_ net261 _0404_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_38_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2828_ clknet_4_11_0_clk _0350_ VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2759_ clknet_4_0_0_clk _0337_ _0153_ VGND VGND VPWR VPWR rf.registers\[10\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1894__A net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1788__B net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1992_ _0897_ _0898_ _0855_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload10 clknet_4_11_0_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__inv_8
XFILLER_0_70_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2613_ _1270_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__inv_2
XFILLER_0_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2544_ _1262_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2475_ _1250_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__buf_4
XFILLER_0_76_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1426_ _0435_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1357_ net141 net66 VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__nor2_4
XFILLER_0_78_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1288_ net236 _0356_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__and2_1
XANTENNA__1698__B _0631_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload4 clknet_4_4_0_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_0_18_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1947__A2 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1889__A net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1401__B _0415_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2260_ _0594_ _1136_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__xnor2_1
X_2191_ _0907_ _0885_ _1080_ net62 VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_48_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1975_ _0825_ _0827_ net100 VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2527_ _1260_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__buf_4
XFILLER_0_11_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2458_ _1251_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__inv_2
XFILLER_0_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold38 ssdc.clk_divider\[1\] VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 rf.registers\[10\]\[3\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dlygate4sd3_1
X_1409_ _0427_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__clkbuf_1
X_2389_ ssdc.clk_divider\[4\] ssdc.clk_divider\[6\] VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__nand2_1
Xhold49 ssdc.clk_divider\[6\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2290__A1 _1022_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1856__A1 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2508__A _1255_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1760_ _0394_ _0687_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1691_ net71 VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__inv_2
XFILLER_0_20_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2312_ _1166_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2243_ _1123_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__clkbuf_1
X_2174_ _0396_ _0557_ net97 VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__o21a_1
XFILLER_0_87_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1958_ _0866_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__clkbuf_1
X_1889_ net71 _0798_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__nand2_1
Xoutput39 net39 VGND VGND VPWR VPWR an[2] sky130_fd_sc_hd__clkbuf_4
Xoutput17 net17 VGND VGND VPWR VPWR Result[23] sky130_fd_sc_hd__buf_2
Xoutput28 net28 VGND VGND VPWR VPWR Result[4] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_67_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1774__B1 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1526__B1 _0490_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1407__A _0403_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output20_A net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2792_ clknet_4_0_0_clk _0185_ _0023_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dfrtp_4
X_1812_ _0706_ _0713_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__nand2_1
X_1743_ _0617_ _0622_ _0616_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_25_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1674_ _0528_ _0609_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__or2_4
XFILLER_0_4_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2226_ _1109_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2157_ _0680_ _0683_ _0701_ _0630_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__a31o_1
X_2088_ net122 _0923_ _0932_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_64_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2236__A1 _1117_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1897__A net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1390_ _0417_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2172__B1 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2011_ _0813_ _0819_ _0806_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_61_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1986__A0 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2775_ clknet_4_7_0_clk _0168_ _0006_ VGND VGND VPWR VPWR rf.registers\[10\]\[16\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold135 rf.registers\[25\]\[2\] VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
X_1726_ rf.registers\[25\]\[8\] _0473_ _0481_ rf.registers\[10\]\[8\] VGND VGND VPWR
+ VPWR _0656_ sky130_fd_sc_hd__a22o_1
Xhold102 rf.registers\[10\]\[11\] VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
Xhold113 rf.registers\[25\]\[28\] VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlygate4sd3_1
Xhold124 rf.registers\[25\]\[23\] VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
X_1657_ _0520_ _0539_ net68 VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__a21o_1
Xhold146 rf.registers\[15\]\[29\] VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
Xhold157 rf.registers\[10\]\[5\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1588_ net123 _0533_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_69_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2209_ _0862_ _0962_ _1094_ _1095_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__o22ai_4
XANTENNA__2218__B2 _0631_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2341__A _0577_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2560_ _1260_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__buf_4
X_2491_ _1256_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__inv_2
X_1511_ net91 VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1442_ net308 _0438_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__and2_1
XANTENNA__2775__CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1373_ _0408_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2827_ clknet_4_11_0_clk _0349_ VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2758_ clknet_4_6_0_clk _0336_ _0152_ VGND VGND VPWR VPWR rf.registers\[15\]\[31\]
+ sky130_fd_sc_hd__dfrtp_1
X_1709_ net101 net131 _0640_ net186 VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__o31a_1
X_2689_ clknet_4_12_0_clk _0267_ _0083_ VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dfrtp_1
XANTENNA__1505__A _0478_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1878__C net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1991_ _0849_ _0852_ _0800_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2612_ _1270_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__inv_2
Xclkload11 clknet_4_12_0_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_11_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2543_ _1262_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2474_ _1252_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__inv_2
XFILLER_0_76_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1425_ net286 _0426_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__and2_1
X_1356_ net1 net142 VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__and2_2
XFILLER_0_78_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1287_ _0359_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__1995__A _0840_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload5 clknet_4_6_0_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__inv_6
XFILLER_0_73_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1947__A3 net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2066__A _0631_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2190_ _1072_ _1079_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_48_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1974_ net111 _0878_ _0880_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_70_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2526_ rst VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__clkbuf_4
X_2457_ _1251_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__inv_2
Xhold28 ssdc.clk_divider\[17\] VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dlygate4sd3_1
X_1408_ net284 _0426_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2388_ _1206_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__clkbuf_1
Xhold39 _0222_ VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1339_ _0386_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1929__S _0840_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1690_ rf.registers\[25\]\[12\] _0473_ _0480_ rf.registers\[10\]\[12\] VGND VGND
+ VPWR VPWR net71 sky130_fd_sc_hd__a22o_1
XFILLER_0_52_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output98_A net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2311_ net5 _1091_ _1162_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__mux2_1
X_2242_ net278 _1122_ _1087_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__mux2_1
X_2173_ _1063_ _0650_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__nand2_1
XANTENNA__1603__A net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1957_ net277 _0865_ net139 VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__mux2_1
XANTENNA__2709__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1888_ net72 _0798_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput18 net18 VGND VGND VPWR VPWR Result[24] sky130_fd_sc_hd__buf_2
Xoutput29 net29 VGND VGND VPWR VPWR Result[5] sky130_fd_sc_hd__buf_2
XFILLER_0_11_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2509_ _1258_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__inv_2
XFILLER_0_11_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2519__A _1255_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1811_ _0695_ _0727_ _0728_ _0732_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__o31a_1
X_2791_ clknet_4_0_0_clk _0184_ _0022_ VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_25_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1742_ _0651_ _0669_ _0670_ _0643_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__o22a_1
XFILLER_0_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1673_ _0503_ _0511_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2225_ net250 _1108_ _1087_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2156_ _0680_ _0683_ _0701_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_88_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2087_ _0916_ _0924_ _0848_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_64_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2164__A net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1508__A _0481_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2339__A _0787_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1897__B _0795_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2172__A1 net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2010_ _0805_ _0810_ _0806_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_78_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1986__A1 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_45_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2774_ clknet_4_3_0_clk _0167_ _0005_ VGND VGND VPWR VPWR rf.registers\[10\]\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1725_ net99 _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__xor2_1
XFILLER_0_53_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold114 rf.registers\[5\]\[24\] VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
Xhold125 rf.registers\[15\]\[28\] VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dlygate4sd3_1
Xhold103 rf.registers\[25\]\[10\] VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_44_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold147 rf.registers\[25\]\[1\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
Xhold136 rf.registers\[5\]\[19\] VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
X_1656_ _0593_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dlymetal6s2s_1
Xhold158 rf.registers\[10\]\[31\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlygate4sd3_1
X_1587_ net121 net120 _0532_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_69_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2208_ _1093_ _1063_ _1069_ _0630_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_53_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2139_ _1034_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1937__S net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_62_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2154__A1 _1047_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1968__A1 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2532__A _1261_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output80_A net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2490_ _1255_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__buf_2
X_1510_ rf.registers\[25\]\[30\] net140 _0483_ rf.registers\[10\]\[30\] VGND VGND
+ VPWR VPWR net91 sky130_fd_sc_hd__a22o_2
X_1441_ _0443_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2145__A1 _1025_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1372_ net338 _0404_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2826_ clknet_4_10_0_clk net229 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2757_ clknet_4_6_0_clk _0335_ _0151_ VGND VGND VPWR VPWR rf.registers\[15\]\[30\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1708_ net130 _0514_ _0526_ _0523_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__or4_4
X_2688_ clknet_4_12_0_clk _0266_ _0082_ VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dfrtp_1
X_1639_ _0517_ net193 _0578_ net195 VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__o31ai_1
XANTENNA__2136__A1 _1025_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2352__A _0577_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2527__A _1260_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1431__A _0437_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1990_ _0837_ _0850_ _0800_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2611_ _1270_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__inv_2
Xclkload12 clknet_4_13_0_clk VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__inv_6
XFILLER_0_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2542_ _1262_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__inv_2
X_2473_ _1252_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__inv_2
XANTENNA__2118__A1 _1015_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1424_ _0354_ _0398_ net209 VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1355_ net141 _0390_ net60 VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__a21o_1
X_1286_ net302 _0356_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__and2_1
XANTENNA__1629__B1 _0480_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1995__B net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkload6 clknet_4_7_0_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__inv_6
XFILLER_0_33_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2809_ clknet_4_5_0_clk _0202_ _0040_ VGND VGND VPWR VPWR rf.registers\[5\]\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2347__A net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1859__B1 net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output43_A net43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1973_ _0840_ _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__or2_1
XFILLER_0_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2525_ _1259_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__inv_2
X_2456_ _1251_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__inv_2
Xhold29 _1246_ VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlygate4sd3_1
X_1407_ _0403_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__clkbuf_2
X_2387_ ssdc.digit_select\[1\] ssdc.digit_select\[0\] VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_3_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1338_ rf.registers\[5\]\[4\] _0378_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__and2_1
XFILLER_0_78_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2275__A0 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2266__B1 _0787_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2310_ _1165_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__clkbuf_1
X_2241_ _0921_ _1025_ _1120_ _1121_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_57_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2172_ net60 _0647_ net69 VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1956_ _0483_ VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_1
X_1887_ _0629_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__inv_2
XFILLER_0_31_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput19 net19 VGND VGND VPWR VPWR Result[25] sky130_fd_sc_hd__buf_2
X_2508_ _1255_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__buf_4
X_2439_ ssdc.clk_divider\[15\] ssdc.clk_divider\[14\] _1235_ VGND VGND VPWR VPWR _1242_
+ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_59_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1526__A2 _0479_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2535__A _1261_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1810_ _0729_ _0730_ _0731_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_65_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2790_ clknet_4_12_0_clk _0183_ _0021_ VGND VGND VPWR VPWR rf.registers\[10\]\[31\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_4_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1741_ _0644_ _0649_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1672_ _0608_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__clkbuf_2
XANTENNA__2270__A _0400_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2224_ _0787_ _1067_ _1107_ _0862_ _1001_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__o32ai_4
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2155_ _1048_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2086_ net125 _0984_ _0986_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_75_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1939_ net85 _0796_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2265__A net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2773_ clknet_4_3_0_clk _0166_ _0004_ VGND VGND VPWR VPWR rf.registers\[10\]\[14\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_53_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1724_ _0541_ _0653_ _0394_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold126 rf.registers\[15\]\[26\] VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
Xhold115 rf.registers\[5\]\[14\] VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
Xhold104 rf.registers\[10\]\[2\] VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
X_1655_ rf.registers\[25\]\[0\] _0472_ _0478_ rf.registers\[10\]\[0\] VGND VGND VPWR
+ VPWR _0593_ sky130_fd_sc_hd__a22o_1
Xhold148 rf.registers\[25\]\[3\] VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
Xhold137 rf.registers\[25\]\[15\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1586_ net119 _0531_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_69_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2207_ _1063_ _1069_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2138_ net294 _1033_ _1016_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__mux2_1
X_2069_ net184 _0883_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_24_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2085__A net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2090__A1 _0790_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1440_ net259 _0438_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__and2_1
XFILLER_0_49_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output73_A net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1371_ _0407_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2671__CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_38_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_74_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2825_ clknet_4_6_0_clk _0218_ _0056_ VGND VGND VPWR VPWR rf.registers\[5\]\[31\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_33_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2756_ clknet_4_6_0_clk _0334_ _0150_ VGND VGND VPWR VPWR rf.registers\[15\]\[29\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1707_ _0613_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__inv_2
X_2687_ clknet_4_13_0_clk _0265_ _0081_ VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_69_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1638_ _0521_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__clkbuf_4
X_1569_ _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__inv_2
XANTENNA__1802__A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2019__S net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_output111_A net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2063__A1 _0787_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_43_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2610_ _1270_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__inv_2
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload13 clknet_4_14_0_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__clkinv_4
X_2541_ _1262_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__inv_2
X_2472_ _1252_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__inv_2
X_1423_ _0434_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__clkbuf_1
X_1354_ _0396_ VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_4
X_1285_ _0358_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1995__C net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload7 clknet_4_8_0_clk VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__inv_8
XFILLER_0_33_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2808_ clknet_4_4_0_clk _0201_ _0039_ VGND VGND VPWR VPWR rf.registers\[5\]\[14\]
+ sky130_fd_sc_hd__dfrtp_1
X_2739_ clknet_4_4_0_clk _0317_ _0133_ VGND VGND VPWR VPWR rf.registers\[15\]\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2347__B _0490_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2363__A _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1859__A1 net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2538__A _1260_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1972_ _0821_ _0824_ _0578_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2524_ _1259_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__inv_2
X_2455_ _1251_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__inv_2
X_2386_ _1205_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__inv_2
X_1406_ _0425_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
X_1337_ _0385_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_3_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2027__A1 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1961__S net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2358__A _1185_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1777__B1 _0481_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2240_ _0575_ _0602_ _1119_ _0630_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2171_ net60 _0642_ net70 VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_73_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2257__A1 _1134_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1955_ _0786_ _0788_ _0864_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_7_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1886_ _0797_ _0799_ _0800_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__mux2_1
XANTENNA__1347__A net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2507_ _1257_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__inv_2
XFILLER_0_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2438_ ssdc.clk_divider\[15\] _1238_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_59_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2369_ _1186_ _1182_ _1187_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_78_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2360__B _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1931__A0 net75 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1740_ _0666_ _0667_ _0668_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1671_ rf.registers\[25\]\[15\] _0473_ _0480_ rf.registers\[10\]\[15\] VGND VGND
+ VPWR VPWR _0608_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1922__A0 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2223_ _1106_ _0659_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__nor2_1
X_2154_ net324 _1047_ _1016_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__mux2_1
X_2085_ net125 _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_64_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1938_ net184 VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_71_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1869_ _0542_ _0783_ net60 VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2157__B1 _0630_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2265__B net61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2772_ clknet_4_3_0_clk _0165_ _0003_ VGND VGND VPWR VPWR rf.registers\[10\]\[13\]
+ sky130_fd_sc_hd__dfrtp_1
X_1723_ net131 _0640_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__xnor2_1
Xhold116 rf.registers\[15\]\[4\] VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
Xhold105 rf.registers\[15\]\[11\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
X_1654_ _0537_ net79 _0590_ _0591_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__and4_1
Xhold149 rf.registers\[15\]\[10\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 rf.registers\[15\]\[8\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
Xhold138 rf.registers\[10\]\[7\] VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
X_1585_ net118 net117 _0530_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__or3_4
XFILLER_0_21_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2206_ _0643_ _0644_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_77_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1360__A net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2137_ _0787_ _1030_ _1032_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__o21ai_2
X_2068_ _0875_ _0881_ _0815_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2040__S net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1370_ rf.registers\[10\]\[29\] _0404_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__and2_1
XFILLER_0_65_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1278__A_N net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2824_ clknet_4_5_0_clk _0217_ _0055_ VGND VGND VPWR VPWR rf.registers\[5\]\[30\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2755_ clknet_4_5_0_clk _0333_ _0149_ VGND VGND VPWR VPWR rf.registers\[15\]\[28\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1706_ _0638_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__buf_2
X_2686_ clknet_4_12_0_clk _0264_ _0080_ VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__dfrtp_1
X_1637_ net1 _0398_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__nand2_2
X_1568_ _0476_ rf.registers\[15\]\[2\] _0486_ rf.registers\[5\]\[2\] VGND VGND VPWR
+ VPWR _0516_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_39_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1499_ _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_1_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2125__S _1016_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload14 clknet_4_15_0_clk VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__inv_8
X_2540_ _1262_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2471_ _1252_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__inv_2
X_1422_ net262 _0426_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__and2_1
XFILLER_0_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1353_ _0395_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__buf_2
XANTENNA__1903__A net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1284_ net260 _0356_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_34_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload8 clknet_4_9_0_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__inv_12
XFILLER_0_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2807_ clknet_4_4_0_clk _0200_ _0038_ VGND VGND VPWR VPWR rf.registers\[5\]\[13\]
+ sky130_fd_sc_hd__dfrtp_1
X_2738_ clknet_4_4_0_clk _0316_ _0132_ VGND VGND VPWR VPWR rf.registers\[15\]\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2669_ clknet_4_7_0_clk _0247_ _0063_ VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_1_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1813__A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2363__B _1183_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1971_ _0818_ _0820_ _0804_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2523_ _1259_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__inv_2
X_2454_ _1251_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__inv_2
X_2385_ ssdc.digit_select\[0\] ssdc.digit_select\[1\] VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__and2b_1
X_1405_ rf.registers\[10\]\[12\] _0415_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__and2_1
X_1336_ net245 _0378_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_3_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 control VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_82_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1808__A net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2549__A _1260_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2170_ _0616_ _0617_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1954_ _0790_ _0833_ _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__o21a_1
XFILLER_0_28_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1885_ _0520_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__clkbuf_4
XANTENNA__1347__B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2506_ _1257_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__inv_2
X_2437_ _1240_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2368_ _1182_ _1184_ _1190_ _1195_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__a31o_1
XFILLER_0_47_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1319_ net258 _0367_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__and2_1
X_2299_ _1159_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1972__S _0578_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1931__A1 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1695__B1 _0481_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1670_ _0570_ _0575_ _0602_ _0604_ _0606_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__a311o_1
XFILLER_0_40_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output96_A net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1922__A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2222_ _1065_ _1105_ _0662_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__o21a_1
X_2153_ _1043_ _0974_ _1045_ _1046_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__a211o_1
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2084_ _0876_ _0920_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__or2_1
XFILLER_0_88_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1937_ _0841_ _0846_ net122 VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1868_ _0534_ net124 VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2166__B2 _1025_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1799_ _0721_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_27_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2562__A _1264_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2771_ clknet_4_3_0_clk _0164_ _0002_ VGND VGND VPWR VPWR rf.registers\[10\]\[12\]
+ sky130_fd_sc_hd__dfrtp_1
X_1722_ _0652_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_41_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1653_ _0518_ _0578_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__nand2_1
Xhold106 rf.registers\[25\]\[19\] VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
Xhold117 rf.registers\[25\]\[24\] VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold139 rf.registers\[15\]\[18\] VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__1906__A net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold128 rf.registers\[25\]\[9\] VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
X_1584_ net116 net115 net114 _0529_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__or4_4
XPHY_EDGE_ROW_13_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2205_ _1092_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__1641__A _0577_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2136_ _1025_ _0947_ _1012_ _0943_ _1031_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__o221a_1
XFILLER_0_76_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2067_ _0748_ _0749_ _0956_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__a21o_1
XFILLER_0_88_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_444 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_31_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2311__A1 _1091_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2768__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2261__A1_N _1025_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2302__A1 _1059_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2823_ clknet_4_6_0_clk _0216_ _0054_ VGND VGND VPWR VPWR rf.registers\[5\]\[29\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2754_ clknet_4_6_0_clk _0332_ _0148_ VGND VGND VPWR VPWR rf.registers\[15\]\[27\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_26_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1705_ rf.registers\[25\]\[11\] _0473_ _0480_ rf.registers\[10\]\[11\] VGND VGND
+ VPWR VPWR _0638_ sky130_fd_sc_hd__a22o_1
XFILLER_0_53_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2685_ clknet_4_12_0_clk _0263_ _0079_ VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dfrtp_1
X_1636_ _0576_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__clkbuf_2
X_1567_ _0476_ rf.registers\[15\]\[3\] _0486_ rf.registers\[5\]\[3\] VGND VGND VPWR
+ VPWR _0515_ sky130_fd_sc_hd__a22o_4
XFILLER_0_39_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1498_ _0472_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_37_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2119_ _1017_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1281__A _0355_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2470_ _1252_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__inv_2
X_1421_ _0433_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__clkbuf_1
X_1352_ _0394_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__buf_2
X_1283_ _0357_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__1903__B _0795_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload9 clknet_4_10_0_clk VGND VGND VPWR VPWR clkload9/Y sky130_fd_sc_hd__inv_8
XFILLER_0_61_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2806_ clknet_4_4_0_clk _0199_ _0037_ VGND VGND VPWR VPWR rf.registers\[5\]\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2737_ clknet_4_1_0_clk _0315_ _0131_ VGND VGND VPWR VPWR rf.registers\[15\]\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_74_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2668_ clknet_4_7_0_clk _0246_ _0062_ VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__dfrtp_1
X_1619_ _0523_ _0526_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2599_ _1268_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_6_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1975__S net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1276__A ssdc.digit_select\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1970_ _0871_ _0875_ _0876_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2570__A _1264_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2522_ _1259_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__inv_2
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2453_ _1250_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__buf_4
X_2384_ net228 ssdc.digit_select\[1\] VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__nand2_1
X_1404_ _0424_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__clkbuf_1
X_1335_ _0384_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_3_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2355__S0 ssdc.digit_select\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1777__A2 _0474_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2565__A _1264_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1953_ net125 _0847_ _0859_ _0862_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__a211o_1
XFILLER_0_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1884_ net74 _0798_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_78_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2505_ _1257_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__inv_2
X_2436_ _1214_ _1237_ _1239_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2367_ _1192_ _1193_ _1194_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_87_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1318_ _0375_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2298_ net322 _1047_ _1151_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_output89_A net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2221_ _0566_ _0607_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__nand2_1
X_2152_ _0975_ _0970_ _0971_ _1019_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__a22o_1
XANTENNA__2674__CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2083_ _0848_ _0919_ _0983_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_8_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1936_ _0815_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_4
X_1867_ _0782_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_1
X_1798_ rf.registers\[25\]\[22\] _0474_ _0481_ rf.registers\[10\]\[22\] VGND VGND
+ VPWR VPWR _0721_ sky130_fd_sc_hd__a22o_1
X_2419_ _1228_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_27_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1983__S _0840_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2770_ clknet_4_2_0_clk _0163_ _0001_ VGND VGND VPWR VPWR rf.registers\[10\]\[11\]
+ sky130_fd_sc_hd__dfrtp_1
X_1721_ rf.registers\[25\]\[9\] _0473_ _0481_ rf.registers\[10\]\[9\] VGND VGND VPWR
+ VPWR _0652_ sky130_fd_sc_hd__a22o_1
XFILLER_0_79_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1652_ net190 _0520_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__nand2_1
Xhold107 rf.registers\[25\]\[12\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
Xhold129 rf.registers\[15\]\[24\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
Xhold118 rf.registers\[5\]\[8\] VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
X_1583_ net113 net112 _0528_ _0512_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__or4_4
XTAP_TAPCELL_ROW_69_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2204_ net289 _1091_ _1087_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__mux2_1
X_2135_ _0926_ _0941_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_77_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2066_ _0631_ VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_24_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1919_ _0816_ _0831_ _0832_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1978__S net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1510__B1 _0483_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2049__S net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2573__A _1265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2822_ clknet_4_5_0_clk _0215_ _0053_ VGND VGND VPWR VPWR rf.registers\[5\]\[28\]
+ sky130_fd_sc_hd__dfrtp_1
X_2753_ clknet_4_5_0_clk _0331_ _0147_ VGND VGND VPWR VPWR rf.registers\[15\]\[26\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1704_ _0628_ _0635_ _0636_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__or3_1
XFILLER_0_41_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2684_ clknet_4_12_0_clk _0262_ _0078_ VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__dfrtp_1
X_1635_ rf.registers\[25\]\[3\] _0472_ _0479_ rf.registers\[10\]\[3\] VGND VGND VPWR
+ VPWR _0576_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1566_ net128 net129 VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__or2_4
X_1497_ _0390_ _0398_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__nor2_2
XFILLER_0_68_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2118_ net306 _1015_ _1016_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2049_ net295 _0953_ net139 VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1737__A net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1420_ net339 _0426_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__and2_1
XFILLER_0_50_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output71_A net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1351_ _0393_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__buf_2
XANTENNA__2568__A _1264_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1282_ net253 _0356_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_50_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1798__B1 _0481_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2805_ clknet_4_4_0_clk _0198_ _0036_ VGND VGND VPWR VPWR rf.registers\[5\]\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2736_ clknet_4_0_0_clk _0314_ _0130_ VGND VGND VPWR VPWR rf.registers\[15\]\[9\]
+ sky130_fd_sc_hd__dfrtp_1
X_2667_ clknet_4_7_0_clk _0245_ _0061_ VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_67_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1618_ net96 VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__inv_2
XFILLER_0_41_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2598_ rst VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__clkbuf_2
X_1549_ net108 net109 VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_6_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1789__B1 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1276__B ssdc.digit_select\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2327__S _0400_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_56_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2521_ _1259_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__inv_2
XFILLER_0_51_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2452_ rst VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__buf_1
X_2383_ _1190_ _1203_ _1201_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1403_ rf.registers\[10\]\[13\] _0415_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__and2_1
X_1334_ net248 _0378_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_3_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1930__A _0677_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2355__S1 ssdc.digit_select\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2719_ clknet_4_15_0_clk _0297_ _0113_ VGND VGND VPWR VPWR rf.registers\[25\]\[24\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2147__S _1016_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1986__S _0578_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1952_ _0861_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__clkbuf_4
XANTENNA__2581__A _1265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1883_ _0795_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__buf_2
XFILLER_0_22_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1925__A net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2504_ _1257_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__inv_2
X_2435_ _1238_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__inv_2
X_2366_ _1186_ _1182_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__or2_1
XANTENNA_clkbuf_4_4_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1317_ net297 _0367_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__and2_1
X_2297_ _1158_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1695__A2 _0474_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2385__B ssdc.digit_select\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2220_ _1104_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2151_ _0630_ _1036_ _1044_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__nor3_1
XANTENNA__2576__A _1265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2082_ _0876_ _0917_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_64_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1935_ _0843_ _0845_ _0840_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1866_ rf.registers\[15\]\[31\] _0479_ _0490_ rf.registers\[5\]\[31\] VGND VGND VPWR
+ VPWR _0782_ sky130_fd_sc_hd__a22o_1
X_1797_ _0395_ net83 _0717_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__or3_1
XFILLER_0_12_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2418_ _1214_ _1225_ _1227_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__and3_1
X_2349_ _0539_ VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__inv_2
XFILLER_0_79_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1601__A2 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2335__S _0400_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1720_ _0643_ _0644_ _0649_ _0650_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__or4b_4
XFILLER_0_53_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1651_ _0589_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__buf_1
Xhold108 rf.registers\[25\]\[25\] VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold119 rf.registers\[5\]\[9\] VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
X_1582_ _0527_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__buf_4
XFILLER_0_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2203_ _0862_ _0944_ _1089_ _1090_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2134_ _0708_ _1005_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_77_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2065_ _0968_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1918_ net196 VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1849_ _0765_ _0766_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1994__S net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_4_12_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2821_ clknet_4_6_0_clk _0214_ _0052_ VGND VGND VPWR VPWR rf.registers\[5\]\[27\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_26_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2752_ clknet_4_5_0_clk _0330_ _0146_ VGND VGND VPWR VPWR rf.registers\[15\]\[25\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1703_ net51 _0634_ _0629_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__o21a_1
XFILLER_0_26_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2683_ clknet_4_12_0_clk _0261_ _0077_ VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__dfrtp_1
X_1634_ net94 _0574_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__nand2_1
X_1565_ rf.registers\[15\]\[7\] _0477_ _0487_ rf.registers\[5\]\[7\] VGND VGND VPWR
+ VPWR net129 sky130_fd_sc_hd__a22o_1
XFILLER_0_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1496_ _0471_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_37_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2117_ _0483_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__buf_4
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2048_ _0938_ _0952_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_79_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1350_ _0392_ _0390_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__nor2_2
X_1281_ _0355_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_58_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2804_ clknet_4_1_0_clk _0197_ _0035_ VGND VGND VPWR VPWR rf.registers\[5\]\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2735_ clknet_4_0_0_clk _0313_ _0129_ VGND VGND VPWR VPWR rf.registers\[15\]\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2666_ clknet_4_6_0_clk _0244_ _0060_ VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dfrtp_1
X_1617_ _0560_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_2
X_2597_ _1267_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__inv_2
X_1548_ _0504_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__buf_1
X_1479_ net309 _0437_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_85_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2520_ _1259_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__inv_2
X_2451_ net206 _1247_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__xnor2_1
XANTENNA__2579__A _1265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1402_ _0423_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__clkbuf_1
X_2382_ _1183_ _1198_ _1197_ _1204_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__o31a_1
X_1333_ _0383_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_4_0_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2718_ clknet_4_14_0_clk _0296_ _0112_ VGND VGND VPWR VPWR rf.registers\[25\]\[23\]
+ sky130_fd_sc_hd__dfrtp_1
X_2649_ clknet_4_11_0_clk _0227_ VGND VGND VPWR VPWR ssdc.clk_divider\[6\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__2489__A rst VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2187__A1 _1077_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1951_ _0860_ _0526_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__or2_1
XFILLER_0_71_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1882_ net73 _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2503_ _1257_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__inv_2
XFILLER_0_51_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2434_ ssdc.clk_divider\[14\] _1235_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__and2_1
X_2365_ _1187_ _1183_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__or2_1
X_1316_ _0374_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2296_ net12 _1041_ _1151_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2102__B2 _0790_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1613__B1 _0481_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xsemi_cpu_top_170 VGND VGND VPWR VPWR semi_cpu_top_170/HI instruction_tb[7] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_181 VGND VGND VPWR VPWR semi_cpu_top_181/HI immediate_tb[16] sky130_fd_sc_hd__conb_1
XANTENNA__1851__A net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1604__B1 net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1761__A net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2150_ _0699_ _1035_ _0694_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__a21oi_1
XANTENNA__2068__S _0815_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2081_ _0757_ _0981_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1843__B1 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1934_ _0834_ _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1865_ _0781_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__clkbuf_2
XANTENNA__1936__A _0815_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1796_ _0395_ _0717_ net83 VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__o21a_1
XFILLER_0_24_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2417_ _1226_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_10_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2323__A1 _1117_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2348_ _1179_ VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
X_2279_ net21 _0967_ _1144_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1650_ rf.registers\[25\]\[1\] _0472_ _0478_ rf.registers\[10\]\[1\] VGND VGND VPWR
+ VPWR _0589_ sky130_fd_sc_hd__a22o_1
XFILLER_0_53_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1581_ _0514_ _0523_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__or3_1
XANTENNA__1475__B _0437_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output94_A net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold109 rf.registers\[25\]\[22\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2305__A1 _1077_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2202_ net62 _1071_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2133_ _1029_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_77_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2064_ net312 _0967_ net139 VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1917_ _0823_ _0830_ _0815_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__mux2_2
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1848_ _0755_ _0761_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1779_ net112 _0685_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__xnor2_1
XANTENNA__2497__A _1255_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_output132_A net132 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1510__A2 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2820_ clknet_4_5_0_clk _0213_ _0051_ VGND VGND VPWR VPWR rf.registers\[5\]\[26\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA__2870__A net43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2751_ clknet_4_5_0_clk _0329_ _0145_ VGND VGND VPWR VPWR rf.registers\[15\]\[24\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1702_ _0629_ net51 _0634_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__nor3_1
XFILLER_0_26_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2682_ clknet_4_13_0_clk _0260_ _0076_ VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__dfrtp_1
X_1633_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__inv_2
X_1564_ _0513_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_1_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1495_ rf.registers\[15\]\[0\] _0399_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__or2_1
XFILLER_0_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2116_ _1010_ _1011_ _1014_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_37_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2047_ _0790_ _0944_ _0947_ _0926_ _0951_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__o221a_1
XFILLER_0_76_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_88_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1280_ net141 _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__nand2_2
XFILLER_0_58_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1798__A2 _0474_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2803_ clknet_4_1_0_clk _0196_ _0034_ VGND VGND VPWR VPWR rf.registers\[5\]\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_42_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1647__C _0578_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2734_ clknet_4_1_0_clk _0312_ _0128_ VGND VGND VPWR VPWR rf.registers\[15\]\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2665_ clknet_4_7_0_clk _0243_ _0059_ VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_1_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1616_ rf.registers\[25\]\[6\] _0473_ _0481_ rf.registers\[10\]\[6\] VGND VGND VPWR
+ VPWR _0560_ sky130_fd_sc_hd__a22o_1
X_2596_ _1267_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__inv_2
XFILLER_0_1_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1547_ rf.registers\[15\]\[18\] _0477_ _0487_ rf.registers\[5\]\[18\] VGND VGND VPWR
+ VPWR _0504_ sky130_fd_sc_hd__a22o_1
X_1478_ _0462_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2450_ _1249_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1483__B _0437_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1401_ net316 _0415_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__and2_1
X_2381_ _1186_ _1182_ _1187_ _1203_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__a22o_1
X_1332_ net233 _0378_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__and2_1
XFILLER_0_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1939__A net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2717_ clknet_4_14_0_clk _0295_ _0111_ VGND VGND VPWR VPWR rf.registers\[25\]\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_72_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2648_ clknet_4_8_0_clk _0226_ VGND VGND VPWR VPWR ssdc.clk_divider\[5\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__1393__B _0415_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2579_ _1265_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__inv_2
XFILLER_0_77_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1584__A net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_29_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_38_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1950_ _0490_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__inv_2
X_1881_ _0795_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__buf_2
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2502_ _1257_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__inv_2
XFILLER_0_51_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_47_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2433_ ssdc.clk_divider\[14\] _1235_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__or2_1
X_2364_ _1191_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__inv_2
X_1315_ rf.registers\[5\]\[15\] _0367_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__and2_1
X_2295_ _1157_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_65_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xsemi_cpu_top_171 VGND VGND VPWR VPWR semi_cpu_top_171/HI instruction_tb[8] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_160 VGND VGND VPWR VPWR semi_cpu_top_160/HI immediate_tb[25] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_58_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_74_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_83_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2080_ _0761_ _0955_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__nand2_1
XANTENNA__2873__A net61 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1933_ net78 net77 _0804_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1864_ rf.registers\[25\]\[31\] net54 _0483_ rf.registers\[10\]\[31\] VGND VGND VPWR
+ VPWR _0781_ sky130_fd_sc_hd__a22o_1
XFILLER_0_3_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1795_ _0718_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__buf_2
X_2416_ ssdc.clk_divider\[7\] ssdc.clk_divider\[8\] _1223_ VGND VGND VPWR VPWR _1226_
+ sky130_fd_sc_hd__and3_1
X_2347_ net139 _0490_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__or2_1
XFILLER_0_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2278_ _1148_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1522__B1 _0490_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1580_ net127 net126 VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__or2_4
XANTENNA_output87_A net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2201_ _0628_ _1062_ _1070_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__and3_1
XFILLER_0_28_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2132_ net313 _1028_ _1016_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_77_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2063_ _0787_ _0958_ _0959_ _0966_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__o31ai_2
XFILLER_0_44_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1916_ _0826_ _0829_ _0806_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1666__B net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_32_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1847_ net85 _0754_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1778_ net80 VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__inv_2
XFILLER_0_85_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output125_A net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1767__A net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2750_ clknet_4_6_0_clk _0328_ _0144_ VGND VGND VPWR VPWR rf.registers\[15\]\[23\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_26_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1701_ _0611_ _0613_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__o21a_1
X_2681_ clknet_4_12_0_clk _0259_ _0075_ VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__dfrtp_1
X_1632_ _0541_ _0572_ _0393_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1563_ rf.registers\[15\]\[6\] _0477_ _0486_ rf.registers\[5\]\[6\] VGND VGND VPWR
+ VPWR _0513_ sky130_fd_sc_hd__a22o_1
XANTENNA__2598__A rst VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1494_ _0470_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2115_ _0847_ _0932_ _1012_ _0831_ _1013_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_37_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2046_ net122 _0948_ _0950_ _0932_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__a211o_1
XFILLER_0_76_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2214__A1 _1099_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1587__A net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1716__B1 _0480_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2802_ clknet_4_1_0_clk _0195_ _0033_ VGND VGND VPWR VPWR rf.registers\[5\]\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_42_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2733_ clknet_4_1_0_clk _0311_ _0127_ VGND VGND VPWR VPWR rf.registers\[15\]\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_81_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2664_ clknet_4_6_0_clk _0242_ _0058_ VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1615_ _0396_ _0557_ net97 VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__o21ai_1
X_2595_ _1267_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__inv_2
X_1546_ rf.registers\[15\]\[17\] _0478_ _0488_ rf.registers\[5\]\[17\] VGND VGND VPWR
+ VPWR net108 sky130_fd_sc_hd__a22o_1
XFILLER_0_22_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2121__A net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1477_ rf.registers\[15\]\[9\] _0437_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__and2_1
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2029_ _0915_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1870__A net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_56_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1400_ _0422_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__clkbuf_1
X_2380_ _1182_ _1183_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__nand2_1
X_1331_ _0382_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2876__A net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2716_ clknet_4_14_0_clk _0294_ _0110_ VGND VGND VPWR VPWR rf.registers\[25\]\[21\]
+ sky130_fd_sc_hd__dfrtp_1
X_2647_ clknet_4_8_0_clk _0225_ VGND VGND VPWR VPWR ssdc.clk_divider\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2353__A0 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2578_ _1265_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__inv_2
X_1529_ _0495_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_2_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2771__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_53_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2344__B1 _1144_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1880_ _0512_ _0794_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__nor2_2
XFILLER_0_83_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2501_ _1257_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__inv_2
XFILLER_0_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2432_ _1235_ net219 VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__nor2_1
XANTENNA__2335__A0 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2363_ _1187_ _1183_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__and2_1
X_1314_ _0373_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__clkbuf_1
X_2294_ net332 _1033_ _1151_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1613__A2 _0474_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xsemi_cpu_top_150 VGND VGND VPWR VPWR semi_cpu_top_150/HI immediate_tb[11] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_172 VGND VGND VPWR VPWR semi_cpu_top_172/HI instruction_tb[9] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_161 VGND VGND VPWR VPWR semi_cpu_top_161/HI immediate_tb[26] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_58_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2667__CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1932_ _0834_ _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1863_ _0779_ _0546_ _0544_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1794_ rf.registers\[25\]\[23\] _0474_ _0481_ rf.registers\[10\]\[23\] VGND VGND
+ VPWR VPWR _0718_ sky130_fd_sc_hd__a22o_1
XFILLER_0_24_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2113__B _0790_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2415_ ssdc.clk_divider\[7\] ssdc.clk_divider\[6\] _1221_ ssdc.clk_divider\[8\] VGND
+ VGND VPWR VPWR _1225_ sky130_fd_sc_hd__a31o_1
XFILLER_0_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2346_ _0538_ _1144_ net66 _0490_ VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__a31o_1
X_2277_ net22 _0953_ _1144_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2275__S _1144_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1399__B _0415_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2304__A _0400_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_69_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2200_ _1088_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2131_ _0787_ _1024_ _1027_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__o21ai_1
X_2062_ _0790_ _0962_ _0963_ _0926_ _0965_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__o221a_1
XFILLER_0_88_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1915_ _0827_ _0828_ _0578_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2241__A2 _1025_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1846_ _0751_ _0757_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1777_ rf.registers\[25\]\[20\] _0474_ _0481_ rf.registers\[10\]\[20\] VGND VGND
+ VPWR VPWR net80 sky130_fd_sc_hd__a22o_2
XFILLER_0_52_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1963__A _0840_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2329_ net27 _1130_ _0400_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__mux2_1
XANTENNA__1902__S _0815_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_23_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output118_A net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1700_ net103 _0613_ net104 VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_5_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2680_ clknet_4_12_0_clk _0258_ _0074_ VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_81_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1631_ net126 _0523_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1562_ _0503_ _0505_ _0507_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__or4_4
X_1493_ rf.registers\[15\]\[1\] _0399_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__or2_1
X_2114_ _0816_ _0926_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_37_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2045_ _0855_ _0898_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_64_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2878_ net59 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1829_ _0396_ net86 _0746_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__or3_1
XFILLER_0_0_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1587__B net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_48_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1964__A1 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1778__A net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_73_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2801_ clknet_4_1_0_clk _0194_ _0032_ VGND VGND VPWR VPWR rf.registers\[5\]\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2732_ clknet_4_1_0_clk _0310_ _0126_ VGND VGND VPWR VPWR rf.registers\[15\]\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_54_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2663_ clknet_4_6_0_clk _0241_ _0057_ VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__dfrtp_1
X_1614_ _0558_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__clkbuf_2
X_2594_ _1267_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__inv_2
X_1545_ net130 net131 net102 net101 VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__or4_4
XFILLER_0_1_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2121__B _0790_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1476_ _0461_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2028_ _0790_ _0922_ _0925_ _0926_ _0933_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__o221a_1
XFILLER_0_49_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2199__A1 _1086_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1330_ net300 _0378_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__and2_1
XANTENNA_output62_A net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1873__B1 _0787_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2715_ clknet_4_14_0_clk _0293_ _0109_ VGND VGND VPWR VPWR rf.registers\[25\]\[20\]
+ sky130_fd_sc_hd__dfrtp_1
X_2646_ clknet_4_8_0_clk _0224_ VGND VGND VPWR VPWR ssdc.clk_divider\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2577_ _1265_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__inv_2
XFILLER_0_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1528_ rf.registers\[15\]\[24\] _0479_ _0490_ rf.registers\[5\]\[24\] VGND VGND VPWR
+ VPWR _0495_ sky130_fd_sc_hd__a22o_1
X_1459_ net321 _0449_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_2_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1864__B1 _0483_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_81_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1616__B1 _0481_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1881__A _0795_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output100_A net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_16_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2500_ _1257_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__inv_2
X_2431_ ssdc.clk_divider\[12\] _1233_ net218 VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__a21oi_1
XANTENNA__2335__A1 _1142_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2362_ _1188_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__nand2_1
X_1313_ net242 _0367_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__and2_1
X_2293_ _1156_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2271__A0 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2023__B1 _0815_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput130 net130 VGND VGND VPWR VPWR rd2_tb[8] sky130_fd_sc_hd__buf_2
X_2629_ _1272_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__inv_2
XFILLER_0_30_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xsemi_cpu_top_173 VGND VGND VPWR VPWR semi_cpu_top_173/HI instruction_tb[10] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_151 VGND VGND VPWR VPWR semi_cpu_top_151/HI immediate_tb[12] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_162 VGND VGND VPWR VPWR semi_cpu_top_162/HI immediate_tb[27] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_58_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2317__A1 _1103_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1828__B1 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_output25_A net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1931_ net75 net76 _0800_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1862_ _0771_ _0553_ _0777_ _0778_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__a31o_1
XFILLER_0_56_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1793_ _0715_ _0716_ _0556_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_24_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2414_ net227 _1223_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2345_ _0538_ _0354_ _0392_ _0397_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__a22o_1
XFILLER_0_74_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2276_ _1147_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1522__A2 _0479_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2130_ _1025_ _0925_ _1012_ _0921_ _1026_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__o221a_1
X_2061_ net122 _0841_ _0932_ _0964_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_77_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1914_ net68 _0798_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1845_ _0761_ _0762_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1776_ _0695_ _0701_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__or2_1
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2328_ _1174_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__clkbuf_1
X_2259_ _0592_ _0595_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__or2b_1
XFILLER_0_67_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2208__B1 _0630_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1630_ _0571_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_2
XANTENNA_output92_A net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1561_ net104 net105 net103 net106 VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__or4_4
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1492_ _0469_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2113_ _0832_ _0790_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_37_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2044_ _0855_ _0834_ _0901_ _0815_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__a31o_1
XFILLER_0_49_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2877_ net140 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1828_ net60 _0746_ net86 VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_44_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1759_ _0685_ _0686_ _0542_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__o21a_1
XFILLER_0_67_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1884__A net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2800_ clknet_4_1_0_clk _0193_ _0031_ VGND VGND VPWR VPWR rf.registers\[5\]\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_42_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2731_ clknet_4_1_0_clk _0309_ _0125_ VGND VGND VPWR VPWR rf.registers\[15\]\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_54_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2662_ clknet_4_8_0_clk net207 VGND VGND VPWR VPWR ssdc.clk_divider\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1613_ rf.registers\[25\]\[7\] _0474_ _0481_ rf.registers\[10\]\[7\] VGND VGND VPWR
+ VPWR _0558_ sky130_fd_sc_hd__a22o_1
X_2593_ _1260_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__clkbuf_2
X_1544_ _0502_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_2
XFILLER_0_1_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1475_ net331 _0437_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__and2_1
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_66_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1969__A _0815_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2027_ net122 _0927_ _0930_ _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__a211o_1
XFILLER_0_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1688__B net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1908__S _0578_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2714_ clknet_4_15_0_clk _0292_ _0108_ VGND VGND VPWR VPWR rf.registers\[25\]\[19\]
+ sky130_fd_sc_hd__dfrtp_1
X_2645_ clknet_4_8_0_clk _0223_ VGND VGND VPWR VPWR ssdc.clk_divider\[2\] sky130_fd_sc_hd__dfxtp_1
X_2576_ _1265_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__inv_2
X_1527_ _0494_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_2
X_1458_ _0452_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1389_ net279 _0415_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_81_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2430_ ssdc.clk_divider\[13\] ssdc.clk_divider\[12\] _1233_ VGND VGND VPWR VPWR _1235_
+ sky130_fd_sc_hd__and3_1
X_2361_ _1186_ _1187_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__or2_1
X_1312_ _0372_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_16_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2292_ net15 _1028_ _1151_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2628_ _1272_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__inv_2
Xoutput131 net131 VGND VGND VPWR VPWR rd2_tb[9] sky130_fd_sc_hd__buf_2
Xoutput120 net120 VGND VGND VPWR VPWR rd2_tb[28] sky130_fd_sc_hd__buf_2
XFILLER_0_10_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2559_ _1263_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_34_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xsemi_cpu_top_174 VGND VGND VPWR VPWR semi_cpu_top_174/HI instruction_tb[11] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_152 VGND VGND VPWR VPWR semi_cpu_top_152/HI immediate_tb[13] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_163 VGND VGND VPWR VPWR semi_cpu_top_163/HI immediate_tb[28] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_58_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_43_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2262__A1 _1138_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1876__B net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1828__A1 net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_61_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_output18_A net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1930_ _0677_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__inv_2
XFILLER_0_56_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1861_ _0550_ _0776_ _0775_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_56_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1792_ net114 _0529_ net115 VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2413_ _1223_ _1224_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2344_ net67 net65 _1144_ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__o21a_1
X_2275_ net23 _0935_ _1144_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1887__A _0629_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1994__A0 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_5_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2171__B1 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2060_ net185 _0856_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_77_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1913_ net79 _0798_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1844_ _0396_ net84 _0759_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__or3_1
X_1775_ _0699_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_68_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2327_ net28 _1126_ _0400_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__mux2_1
X_2258_ _1135_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2189_ _0674_ _1071_ _0636_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_67_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1500__A _0474_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1560_ rf.registers\[15\]\[15\] _0478_ _0488_ rf.registers\[5\]\[15\] VGND VGND VPWR
+ VPWR net106 sky130_fd_sc_hd__a22o_4
XFILLER_0_22_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output85_A net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1491_ rf.registers\[15\]\[2\] _0399_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__or2_1
X_2112_ _1009_ _0736_ _1008_ _0630_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__a31o_1
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2043_ _0889_ _0897_ _0855_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2876_ net139 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1827_ _0747_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__buf_2
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2151__A _0630_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1758_ _0505_ net107 _0528_ _0609_ net110 VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__o41a_1
X_1689_ _0616_ _0617_ _0622_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__or4_4
XANTENNA__2774__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2730_ clknet_4_1_0_clk _0308_ _0124_ VGND VGND VPWR VPWR rf.registers\[15\]\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_2661_ clknet_4_8_0_clk _0239_ VGND VGND VPWR VPWR ssdc.clk_divider\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_81_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1612_ _0528_ _0554_ _0556_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2592_ _1266_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1543_ rf.registers\[15\]\[8\] _0476_ _0486_ rf.registers\[5\]\[8\] VGND VGND VPWR
+ VPWR _0502_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1474_ _0460_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2026_ _0931_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__buf_2
XFILLER_0_82_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1895__A net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2713_ clknet_4_14_0_clk _0291_ _0107_ VGND VGND VPWR VPWR rf.registers\[25\]\[18\]
+ sky130_fd_sc_hd__dfrtp_1
X_2644_ clknet_4_8_0_clk net221 VGND VGND VPWR VPWR ssdc.clk_divider\[1\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__2338__B1 _1144_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2575_ _1265_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__inv_2
X_1526_ rf.registers\[15\]\[25\] _0479_ _0490_ rf.registers\[5\]\[25\] VGND VGND VPWR
+ VPWR _0494_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1457_ net271 _0449_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__and2_1
X_1388_ _0416_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_81_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2009_ _0913_ _0914_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2604__A _1268_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_36_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2360_ _1186_ _1187_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__nand2_1
X_1311_ net238 _0367_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__and2_1
X_2291_ _1155_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput110 net110 VGND VGND VPWR VPWR rd2_tb[19] sky130_fd_sc_hd__buf_2
XFILLER_0_30_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput132 net132 VGND VGND VPWR VPWR seg[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2627_ _1272_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__inv_2
Xoutput121 net121 VGND VGND VPWR VPWR rd2_tb[29] sky130_fd_sc_hd__buf_2
X_2558_ _1263_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xsemi_cpu_top_175 VGND VGND VPWR VPWR semi_cpu_top_175/HI instruction_tb[12] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_153 VGND VGND VPWR VPWR semi_cpu_top_153/HI immediate_tb[18] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_164 VGND VGND VPWR VPWR semi_cpu_top_164/HI immediate_tb[29] sky130_fd_sc_hd__conb_1
X_2489_ rst VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__dlymetal6s2s_1
X_1509_ _0482_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_58_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1876__C net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2708__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1860_ _0775_ _0776_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__nor2_1
XFILLER_0_71_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1791_ net115 net114 _0529_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__or3_1
XFILLER_0_24_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2412_ net231 _1221_ _1214_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__o21ai_1
X_2343_ _0577_ _0860_ VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__nand2_1
XFILLER_0_58_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2274_ _1146_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1323__A _0355_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1819__A2 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1989_ _0890_ _0895_ _0876_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_26_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1994__A1 net87 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2171__A1 net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_88_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1797__B net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1912_ _0824_ _0825_ _0804_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1985__B2 _0677_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1843_ _0396_ _0759_ net84 VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_4_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1774_ _0396_ _0698_ net76 VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_68_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2326_ _1173_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__clkbuf_1
X_2257_ net317 _1134_ _0483_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__mux2_1
XANTENNA__2149__A net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2188_ _1078_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_80_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1976__B2 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1927__S net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1898__A net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1490_ _0468_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output78_A net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2111_ _0736_ _1008_ _1009_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__a21oi_1
X_2042_ _0945_ _0946_ net122 VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1655__B1 _0478_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2875_ net139 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1826_ rf.registers\[25\]\[26\] net140 _0482_ rf.registers\[10\]\[26\] VGND VGND
+ VPWR VPWR _0747_ sky130_fd_sc_hd__a22o_1
XFILLER_0_4_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1757_ _0512_ _0528_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1688_ _0394_ net73 _0620_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__nor3_2
XFILLER_0_40_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2309_ net6 _1086_ _1162_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1511__A net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1405__B _0415_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output116_A net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2660_ clknet_4_8_0_clk _0238_ VGND VGND VPWR VPWR ssdc.clk_divider\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1611_ _0555_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2591_ _1266_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__inv_2
X_1542_ _0477_ rf.registers\[15\]\[11\] _0487_ rf.registers\[5\]\[11\] VGND VGND VPWR
+ VPWR net102 sky130_fd_sc_hd__a22o_1
X_1473_ net287 _0437_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1628__B1 net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2025_ net197 _0862_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1809_ net78 _0688_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__or2_1
X_2789_ clknet_4_15_0_clk _0182_ _0020_ VGND VGND VPWR VPWR rf.registers\[10\]\[30\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_60_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1506__A _0479_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2101__S net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__2044__B1 _0815_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2712_ clknet_4_14_0_clk _0290_ _0106_ VGND VGND VPWR VPWR rf.registers\[25\]\[17\]
+ sky130_fd_sc_hd__dfrtp_1
X_2643_ clknet_4_10_0_clk _0221_ VGND VGND VPWR VPWR ssdc.clk_divider\[0\] sky130_fd_sc_hd__dfxtp_1
XANTENNA__2338__A1 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_2_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2574_ _1265_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__inv_2
X_1525_ _0493_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1456_ _0451_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__clkbuf_1
X_1387_ net266 _0415_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_81_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2008_ _0550_ _0912_ _0777_ _0631_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__o31a_1
XANTENNA__1996__A net91 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2329__A1 _1130_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1935__S _0840_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_60_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1552__A2 _0478_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2530__A _1261_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output60_A net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1310_ _0371_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__clkbuf_1
X_2290_ net16 _1022_ _1151_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2008__B1 _0631_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput100 net100 VGND VGND VPWR VPWR rd2_tb[0] sky130_fd_sc_hd__buf_2
X_2626_ _1268_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__buf_4
XFILLER_0_42_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput133 net133 VGND VGND VPWR VPWR seg[1] sky130_fd_sc_hd__clkbuf_4
Xoutput111 net111 VGND VGND VPWR VPWR rd2_tb[1] sky130_fd_sc_hd__buf_2
Xoutput122 net122 VGND VGND VPWR VPWR rd2_tb[2] sky130_fd_sc_hd__buf_2
XANTENNA__1534__A2 _0478_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2557_ _1263_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__inv_2
XFILLER_0_56_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xsemi_cpu_top_143 VGND VGND VPWR VPWR semi_cpu_top_143/HI immediate_tb[4] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_154 VGND VGND VPWR VPWR semi_cpu_top_154/HI immediate_tb[19] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_165 VGND VGND VPWR VPWR semi_cpu_top_165/HI immediate_tb[30] sky130_fd_sc_hd__conb_1
X_2488_ _1254_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__inv_2
X_1508_ _0481_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__clkbuf_4
X_1439_ _0442_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__clkbuf_1
Xsemi_cpu_top_176 VGND VGND VPWR VPWR semi_cpu_top_176/HI instruction_tb[13] sky130_fd_sc_hd__conb_1
X_2872__180 VGND VGND VPWR VPWR _2872__180/HI net180 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_66_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2615__A _1268_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_13_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2350__A _0392_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1790_ _0712_ _0713_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2411_ ssdc.clk_divider\[6\] _1221_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__and2_1
XANTENNA__1516__A2 _0479_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2342_ net141 net66 net142 _0354_ net64 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__o32a_1
X_2273_ net25 _0910_ _1144_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1988_ _0892_ _0894_ _0840_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1755__A2 _0474_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2609_ _1270_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__inv_2
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_26_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output23_A net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1911_ net90 _0798_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_60_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1842_ _0760_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__buf_2
XFILLER_0_56_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1773_ _0395_ net76 _0698_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__or3_2
XFILLER_0_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_68_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2325_ net29 _1122_ _0400_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__mux2_1
X_2256_ _0848_ _0883_ _1043_ _1133_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__a31o_1
XFILLER_0_79_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2187_ net319 _1077_ _1016_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2110_ _0719_ _0720_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__or2b_1
X_2041_ _0868_ _0892_ _0855_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2874_ net48 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1825_ _0531_ _0745_ _0556_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1756_ _0684_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__buf_2
XFILLER_0_4_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1687_ _0393_ _0620_ net73 VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2308_ _1164_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__clkbuf_1
X_2239_ _0575_ _0602_ _1119_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__a21oi_1
XANTENNA__2670__CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1702__A _0629_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2533__A _1261_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2062__A1 _0790_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_42_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1610_ _0537_ _0539_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2590_ _1266_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__inv_2
X_1541_ _0501_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_4
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1472_ _0459_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__clkbuf_1
X_2024_ _0855_ _0854_ _0929_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1808_ net77 _0693_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2788_ clknet_4_12_0_clk _0181_ _0019_ VGND VGND VPWR VPWR rf.registers\[10\]\[29\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1739_ net99 _0654_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_5_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2528__A _1261_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2711_ clknet_4_14_0_clk _0289_ _0105_ VGND VGND VPWR VPWR rf.registers\[25\]\[16\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_54_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1794__B1 _0481_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2642_ _0350_ _1214_ _1275_ ssdc.digit_select\[1\] VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_10_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2338__A2 _0392_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2573_ _1265_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__inv_2
X_1524_ rf.registers\[15\]\[26\] _0479_ _0488_ rf.registers\[5\]\[26\] VGND VGND VPWR
+ VPWR _0493_ sky130_fd_sc_hd__a22o_1
X_1455_ net327 _0449_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__and2_1
X_1386_ _0403_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_2_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2007_ _0550_ _0912_ _0777_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1996__B _0840_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1528__B1 _0490_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2022__S net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2625_ _1271_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__inv_2
Xoutput101 net101 VGND VGND VPWR VPWR rd2_tb[10] sky130_fd_sc_hd__buf_2
XFILLER_0_42_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput134 net134 VGND VGND VPWR VPWR seg[2] sky130_fd_sc_hd__clkbuf_4
Xoutput112 net112 VGND VGND VPWR VPWR rd2_tb[20] sky130_fd_sc_hd__buf_2
Xoutput123 net123 VGND VGND VPWR VPWR rd2_tb[30] sky130_fd_sc_hd__buf_2
XANTENNA__1519__B1 _0490_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2556_ _1263_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__inv_2
Xsemi_cpu_top_144 VGND VGND VPWR VPWR semi_cpu_top_144/HI immediate_tb[5] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_155 VGND VGND VPWR VPWR semi_cpu_top_155/HI immediate_tb[20] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_166 VGND VGND VPWR VPWR semi_cpu_top_166/HI immediate_tb[31] sky130_fd_sc_hd__conb_1
X_1507_ _0480_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__clkbuf_4
X_2487_ _1254_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1438_ net307 _0438_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__and2_1
Xsemi_cpu_top_177 VGND VGND VPWR VPWR semi_cpu_top_177/HI instruction_tb[18] sky130_fd_sc_hd__conb_1
XFILLER_0_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1369_ _0406_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_66_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2247__A1 _1126_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_12_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2350__B net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_21_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2017__S net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2410_ _1221_ net217 VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2174__B1 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2341_ _0577_ VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__inv_2
X_2272_ _1145_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_63_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1987_ _0834_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2608_ _1270_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__inv_2
XFILLER_0_30_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2539_ _1262_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__inv_2
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__2626__A _1268_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_26_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1979__A0 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2536__A _1261_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2255__B _0631_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1910_ net93 _0795_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__nand2_1
X_1841_ rf.registers\[25\]\[24\] net140 _0482_ rf.registers\[10\]\[24\] VGND VGND
+ VPWR VPWR _0760_ sky130_fd_sc_hd__a22o_1
XFILLER_0_56_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1772_ _0691_ _0697_ _0556_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2324_ _1172_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2255_ _0598_ _0631_ _1132_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__and3_1
XANTENNA_clkbuf_4_7_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2186_ _0631_ _1074_ _1075_ _1076_ _0907_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__a32o_1
XFILLER_0_79_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1350__A _0392_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_87_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2356__A _1183_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2030__S net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2040_ _0887_ _0894_ net111 VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2873_ net61 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_4_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1824_ net117 _0530_ net118 VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_25_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1755_ rf.registers\[25\]\[19\] _0474_ _0482_ rf.registers\[10\]\[19\] VGND VGND
+ VPWR VPWR _0684_ sky130_fd_sc_hd__a22o_1
XFILLER_0_4_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1686_ _0621_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_29_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2307_ net7 _1081_ _1162_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__mux2_1
X_2238_ _0570_ _0603_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2169_ _1060_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1702__B net51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1540_ rf.registers\[15\]\[9\] _0476_ _0486_ rf.registers\[5\]\[9\] VGND VGND VPWR
+ VPWR _0501_ sky130_fd_sc_hd__a22o_1
XANTENNA_output83_A net83 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1471_ net283 _0449_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2023_ _0855_ _0834_ _0928_ _0815_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_59_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1807_ net78 _0688_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2787_ clknet_4_9_0_clk _0180_ _0018_ VGND VGND VPWR VPWR rf.registers\[10\]\[28\]
+ sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_68_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1738_ net98 _0658_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__and2_1
X_1669_ _0605_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__inv_2
XFILLER_0_40_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_86_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_4_15_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output121_A net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2710_ clknet_4_3_0_clk _0288_ _0104_ VGND VGND VPWR VPWR rf.registers\[25\]\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2641_ _1205_ _1214_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2572_ _1265_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__inv_2
X_1523_ _0492_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dlymetal6s2s_1
X_1454_ _0450_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__clkbuf_1
X_1385_ _0414_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2006_ _0553_ _0771_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2624_ _1271_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__inv_2
XANTENNA__1618__A net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput102 net187 VGND VGND VPWR VPWR rd2_tb[11] sky130_fd_sc_hd__buf_2
Xoutput113 net113 VGND VGND VPWR VPWR rd2_tb[21] sky130_fd_sc_hd__buf_2
Xoutput124 net124 VGND VGND VPWR VPWR rd2_tb[31] sky130_fd_sc_hd__buf_2
Xoutput135 net135 VGND VGND VPWR VPWR seg[3] sky130_fd_sc_hd__clkbuf_4
X_2555_ _1263_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2192__A1 _1081_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xsemi_cpu_top_145 VGND VGND VPWR VPWR semi_cpu_top_145/HI immediate_tb[6] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_156 VGND VGND VPWR VPWR semi_cpu_top_156/HI immediate_tb[21] sky130_fd_sc_hd__conb_1
X_1506_ _0479_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__clkbuf_4
X_2486_ _1250_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__buf_1
Xsemi_cpu_top_167 VGND VGND VPWR VPWR semi_cpu_top_167/HI instruction_tb[4] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_178 VGND VGND VPWR VPWR semi_cpu_top_178/HI instruction_tb[21] sky130_fd_sc_hd__conb_1
X_1437_ _0441_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__clkbuf_1
X_1368_ net335 _0404_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_58_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1299_ _0365_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_66_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1997__A1 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_12_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2340_ _0392_ _0390_ VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__nor2_1
XFILLER_0_20_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2271_ net26 _0865_ _1144_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__mux2_1
XANTENNA__1685__B1 _0480_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2229__A2 _1025_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1986_ net77 net76 _0578_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_3_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2607_ _1270_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__inv_2
XFILLER_0_61_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2538_ _1260_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__buf_4
X_2469_ _1252_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_26_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2118__S _1016_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_65_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1979__A1 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1957__S net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2361__B _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1840_ _0530_ _0758_ _0556_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_71_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1771_ net107 _0610_ net108 VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_69_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2323_ net30 _1117_ _1162_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_68_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2254_ _0592_ _0596_ _0597_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__or3_1
XFILLER_0_79_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2185_ _0833_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__inv_2
XFILLER_0_79_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1969_ _0815_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_31_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2138__A1 _1033_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2637__A _1268_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2373__A2_N _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2872_ net180 VGND VGND VPWR VPWR immediate_tb[15] sky130_fd_sc_hd__buf_2
XFILLER_0_72_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1823_ net87 _0743_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__xnor2_1
X_1754_ _0664_ _0676_ _0682_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1685_ rf.registers\[25\]\[14\] _0473_ _0480_ rf.registers\[10\]\[14\] VGND VGND
+ VPWR VPWR _0621_ sky130_fd_sc_hd__a22o_1
XANTENNA__1345__B _0355_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2306_ _1163_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__clkbuf_1
X_2237_ _1118_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2168_ rf.registers\[25\]\[16\] _1059_ _1016_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2099_ _0940_ _0942_ _0876_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_4_11_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_39_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1470_ _0458_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_22_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_output76_A net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2286__A0 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2022_ net89 net88 net100 VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1806_ _0680_ _0700_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__and2_1
XFILLER_0_13_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2786_ clknet_4_15_0_clk _0179_ _0017_ VGND VGND VPWR VPWR rf.registers\[10\]\[27\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA__1356__A net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1737_ net99 _0654_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__and2_1
XFILLER_0_40_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1668_ net96 _0564_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_5_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1599_ _0543_ _0484_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_84_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2277__A0 net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_47_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2640_ _1274_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2560__A _1260_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1794__A2 _0474_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2571_ _1260_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1546__A2 _0478_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1522_ rf.registers\[15\]\[27\] _0479_ _0490_ rf.registers\[5\]\[27\] VGND VGND VPWR
+ VPWR _0492_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1453_ net304 _0449_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__and2_1
XANTENNA__1904__A net96 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1384_ net254 _0404_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_2_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2005_ _0911_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_81_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2769_ clknet_4_2_0_clk _0347_ _0000_ VGND VGND VPWR VPWR rf.registers\[10\]\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_52_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1528__A2 _0479_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2623_ _1271_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__inv_2
XFILLER_0_42_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2554_ _1263_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__inv_2
Xoutput125 net125 VGND VGND VPWR VPWR rd2_tb[3] sky130_fd_sc_hd__buf_2
Xoutput103 net103 VGND VGND VPWR VPWR rd2_tb[12] sky130_fd_sc_hd__buf_2
Xoutput114 net114 VGND VGND VPWR VPWR rd2_tb[22] sky130_fd_sc_hd__buf_2
XANTENNA__1519__A2 _0480_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput136 net136 VGND VGND VPWR VPWR seg[4] sky130_fd_sc_hd__clkbuf_4
X_1505_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xsemi_cpu_top_146 VGND VGND VPWR VPWR semi_cpu_top_146/HI immediate_tb[7] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_157 VGND VGND VPWR VPWR semi_cpu_top_157/HI immediate_tb[22] sky130_fd_sc_hd__conb_1
XANTENNA__1634__A net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2485_ _1253_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__inv_2
Xsemi_cpu_top_168 VGND VGND VPWR VPWR semi_cpu_top_168/HI instruction_tb[5] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_179 VGND VGND VPWR VPWR semi_cpu_top_179/HI immediate_tb[17] sky130_fd_sc_hd__conb_1
X_1436_ net328 _0438_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__and2_1
X_1367_ _0405_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1298_ net243 _0356_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1809__A net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1719__A _0393_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2270_ _0400_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__buf_4
XFILLER_0_87_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1985_ _0800_ _0799_ _0891_ _0677_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__o22a_1
X_2606_ _1270_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__inv_2
X_2537_ _1261_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__inv_2
X_2468_ _1252_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__inv_2
XFILLER_0_54_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1419_ _0432_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__clkbuf_1
X_2399_ ssdc.clk_divider\[0\] net220 VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__xor2_1
XANTENNA__2673__CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1770_ _0696_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__buf_2
XFILLER_0_69_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1355__B1 net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2322_ _1171_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2253_ _1131_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__clkbuf_1
X_2184_ _0622_ _1073_ _1061_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_79_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1968_ net111 _0872_ _0874_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_31_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1899_ _0811_ _0812_ _0520_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_39_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2074__A1 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkload3_A clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output21_A net21 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_76_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2563__A _1264_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2871_ net182 VGND VGND VPWR VPWR immediate_tb[14] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_45_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1822_ _0542_ _0742_ _0396_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1753_ _0680_ _0681_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__nand2_1
X_1684_ _0619_ _0618_ _0556_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1907__A net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_hold46_A ssdc.digit_select\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2305_ net8 _1077_ _1162_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__mux2_1
X_2236_ net281 _1117_ _1087_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__mux2_1
XANTENNA__1361__B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2167_ _1055_ _1056_ _1058_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_0_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2098_ _0631_ _0955_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2047__A1 _0790_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output69_A net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2021_ _0839_ _0851_ _0855_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1805_ _0699_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__inv_2
XFILLER_0_32_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2785_ clknet_4_9_0_clk _0178_ _0016_ VGND VGND VPWR VPWR rf.registers\[10\]\[26\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA__1637__A net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1736_ _0624_ _0637_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2210__A1 _1096_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1356__B net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1667_ _0603_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__inv_2
X_1598_ _0484_ _0543_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_5_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1721__B1 _0481_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2219_ net310 _1103_ _1087_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1712__B1 net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2268__A1 _1142_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2570_ _1264_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__inv_2
XFILLER_0_77_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1521_ _0491_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_50_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1452_ _0437_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1703__B1 _0629_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1383_ _0413_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2004_ rf.registers\[25\]\[30\] _0910_ net139 VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_81_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2768_ clknet_4_3_0_clk _0346_ _0162_ VGND VGND VPWR VPWR rf.registers\[10\]\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1719_ _0393_ net69 _0647_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__or3_4
X_2699_ clknet_4_2_0_clk _0277_ _0093_ VGND VGND VPWR VPWR rf.registers\[25\]\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1361__A_N _0400_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2198__A _0483_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2380__B _1183_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_24_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1933__A0 net78 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2571__A _1260_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2622_ _1271_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__inv_2
XFILLER_0_42_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput104 net104 VGND VGND VPWR VPWR rd2_tb[13] sky130_fd_sc_hd__buf_2
Xoutput115 net115 VGND VGND VPWR VPWR rd2_tb[23] sky130_fd_sc_hd__buf_2
X_2553_ _1263_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__inv_2
Xoutput137 net137 VGND VGND VPWR VPWR seg[5] sky130_fd_sc_hd__clkbuf_4
X_1504_ _0477_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__clkbuf_4
Xoutput126 net126 VGND VGND VPWR VPWR rd2_tb[4] sky130_fd_sc_hd__buf_2
Xsemi_cpu_top_147 VGND VGND VPWR VPWR semi_cpu_top_147/HI immediate_tb[8] sky130_fd_sc_hd__conb_1
X_2484_ _1253_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xsemi_cpu_top_169 VGND VGND VPWR VPWR semi_cpu_top_169/HI instruction_tb[6] sky130_fd_sc_hd__conb_1
Xsemi_cpu_top_158 VGND VGND VPWR VPWR semi_cpu_top_158/HI immediate_tb[23] sky130_fd_sc_hd__conb_1
X_1435_ _0440_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__clkbuf_1
X_1366_ net340 _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__and2_1
X_1297_ _0364_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_66_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_14_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2375__B _1187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1719__B net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2566__A _1264_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output51_A net51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1984_ _0800_ _0796_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2605_ _1270_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2536_ _1261_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2467_ _1252_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__inv_2
X_1418_ net257 _0426_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2398_ _1215_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1349_ _0391_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_78_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2325__S _0400_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_output99_A net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2321_ net31 _1112_ _1162_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__mux2_1
X_2252_ net330 _1130_ _0483_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2183_ _1061_ _0622_ _1073_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_76_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1967_ _0840_ _0873_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_31_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1898_ net99 _0798_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2519_ _1255_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__buf_2
XFILLER_0_59_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2870_ net43 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_45_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1821_ net119 _0531_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1752_ _0677_ _0679_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__nand2_1
X_1683_ _0611_ _0613_ net105 VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1907__B _0795_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2304_ _0400_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__clkbuf_4
X_2235_ _0884_ _1043_ _1115_ _1116_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__a22o_1
X_2166_ _0926_ _0999_ _0995_ _1025_ _1057_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_36_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2097_ _0740_ _0763_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2020_ _0832_ _0907_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__nand2_2
XFILLER_0_82_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2574__A _1265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_28_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1804_ _0708_ _0714_ _0725_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__or3b_1
X_2784_ clknet_4_9_0_clk _0177_ _0015_ VGND VGND VPWR VPWR rf.registers\[10\]\[25\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1735_ _0559_ _0566_ _0607_ _0663_ _0661_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__a311o_1
XFILLER_0_40_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1666_ _0394_ net95 _0568_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__or3_1
XFILLER_0_40_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1597_ _0536_ _0542_ net60 VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_37_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2218_ _0862_ _0987_ _1102_ _0631_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_84_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2149_ net125 _0862_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_55_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1712__A1 _0393_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_55_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2333__S _0400_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1738__A net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1520_ rf.registers\[15\]\[28\] _0479_ _0488_ rf.registers\[5\]\[28\] VGND VGND VPWR
+ VPWR _0491_ sky130_fd_sc_hd__a22o_1
XANTENNA_output81_A net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1451_ _0448_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2569__A _1264_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1382_ net251 _0404_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__and2_1
XANTENNA__1703__A1 net51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1501__B_N net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2003_ _0867_ _0885_ _0906_ _0907_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_82_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2767_ clknet_4_2_0_clk _0345_ _0161_ VGND VGND VPWR VPWR rf.registers\[10\]\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2698_ clknet_4_0_0_clk _0276_ _0092_ VGND VGND VPWR VPWR rf.registers\[25\]\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_1718_ _0394_ _0647_ net69 VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__o21a_1
XFILLER_0_13_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1649_ net90 _0587_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2186__A1 _0631_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1933__A1 net77 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1621__B1 _0393_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2621_ _1271_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__inv_2
X_2552_ _1263_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__inv_2
Xoutput105 net105 VGND VGND VPWR VPWR rd2_tb[14] sky130_fd_sc_hd__buf_2
Xoutput116 net116 VGND VGND VPWR VPWR rd2_tb[24] sky130_fd_sc_hd__buf_2
XFILLER_0_23_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput138 net138 VGND VGND VPWR VPWR seg[6] sky130_fd_sc_hd__clkbuf_4
X_1503_ _0476_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__buf_4
Xoutput127 net127 VGND VGND VPWR VPWR rd2_tb[5] sky130_fd_sc_hd__buf_2
XFILLER_0_10_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xsemi_cpu_top_148 VGND VGND VPWR VPWR semi_cpu_top_148/HI immediate_tb[9] sky130_fd_sc_hd__conb_1
X_2483_ _1253_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__inv_2
Xsemi_cpu_top_159 VGND VGND VPWR VPWR semi_cpu_top_159/HI immediate_tb[24] sky130_fd_sc_hd__conb_1
X_1434_ net237 _0438_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__and2_1
XFILLER_0_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1365_ _0403_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__clkbuf_2
X_1296_ net296 _0356_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2819_ clknet_4_5_0_clk _0212_ _0050_ VGND VGND VPWR VPWR rf.registers\[5\]\[25\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA__2168__A1 _1059_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_57_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2331__A1 _1134_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1751__A _0677_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2582__A _1260_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1983_ _0887_ _0889_ _0840_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2604_ _1268_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__buf_4
XFILLER_0_2_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1926__A _0578_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2535_ _1261_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__inv_2
X_2466_ _1252_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__inv_2
X_1417_ _0431_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2397_ ssdc.clk_divider\[0\] _1214_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__and2b_1
X_1348_ net141 net66 VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__or2b_1
X_1279_ _0353_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_78_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1836__A net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout140 net54 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_4
XANTENNA__2313__A1 _1096_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1824__B1 net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2001__B1 _0630_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2320_ _1170_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__clkbuf_1
X_2251_ _1025_ _0961_ _1128_ _1129_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_20_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2577__A _1265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2182_ _0674_ _1071_ _1072_ _0636_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__a211oi_1
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_18_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1966_ _0811_ _0817_ _0578_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2240__B1 _0630_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1897_ net98 _0795_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2518_ _1258_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__inv_2
XFILLER_0_59_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2449_ _1247_ _1248_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__and2_1
XFILLER_0_75_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2161__S _1016_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_71_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1820_ _0741_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_25_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1751_ _0677_ _0679_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__or2_1
XFILLER_0_52_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1682_ net105 _0611_ _0613_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__or3_4
XFILLER_0_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2303_ _1161_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2100__A _0815_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2234_ _1066_ _0787_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__nor2_1
X_2165_ _1000_ _1012_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_36_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2096_ _0994_ _0995_ net125 VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1949_ _0848_ _0856_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__o21ba_1
XANTENNA__1386__A _0403_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_31_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1803_ _0719_ _0720_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__and3b_1
X_2783_ clknet_4_14_0_clk _0176_ _0014_ VGND VGND VPWR VPWR rf.registers\[10\]\[24\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_53_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1734_ _0662_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__inv_2
XFILLER_0_25_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1665_ _0583_ _0600_ _0601_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__a21o_1
X_1596_ _0541_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__buf_2
XFILLER_0_21_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1653__B _0578_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2217_ _0655_ _1101_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__xnor2_1
XANTENNA__2357__S0 ssdc.digit_select\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2148_ _1042_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__clkbuf_1
X_2079_ _0980_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1450_ net303 _0438_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__and2_1
XANTENNA_output74_A net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1473__B _0437_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1381_ _0412_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2002_ _0546_ _0779_ _0908_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_81_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2766_ clknet_4_2_0_clk _0344_ _0160_ VGND VGND VPWR VPWR rf.registers\[10\]\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1664__A net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2697_ clknet_4_2_0_clk _0275_ _0091_ VGND VGND VPWR VPWR rf.registers\[25\]\[2\]
+ sky130_fd_sc_hd__dfrtp_1
X_1717_ _0648_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__buf_2
X_1648_ _0541_ _0585_ _0586_ _0399_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__a31o_1
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1579_ _0525_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__buf_1
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1839__A net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_51_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2620_ _1271_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2551_ _1263_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__inv_2
Xoutput106 net106 VGND VGND VPWR VPWR rd2_tb[15] sky130_fd_sc_hd__buf_2
XFILLER_0_23_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1502_ _0475_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__buf_6
Xoutput128 net128 VGND VGND VPWR VPWR rd2_tb[6] sky130_fd_sc_hd__buf_2
Xoutput117 net117 VGND VGND VPWR VPWR rd2_tb[25] sky130_fd_sc_hd__buf_2
XFILLER_0_23_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2482_ _1253_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__inv_2
X_1433_ _0439_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__clkbuf_1
Xsemi_cpu_top_149 VGND VGND VPWR VPWR semi_cpu_top_149/HI immediate_tb[10] sky130_fd_sc_hd__conb_1
X_1364_ _0354_ _0398_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__nand2_2
X_1295_ _0363_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2818_ clknet_4_5_0_clk _0211_ _0049_ VGND VGND VPWR VPWR rf.registers\[5\]\[24\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_33_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2749_ clknet_4_5_0_clk _0327_ _0143_ VGND VGND VPWR VPWR rf.registers\[15\]\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_57_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1982_ _0834_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2603_ _1269_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2534_ _1261_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2465_ _1252_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__inv_2
XANTENNA__1942__A net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2396_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__clkbuf_2
X_1416_ net320 _0426_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__and2_1
X_1347_ net1 net142 VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__nand2_2
XANTENNA__1530__B1 _0490_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1278_ net142 net1 VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__and2b_1
XFILLER_0_64_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2086__A1 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1597__B1 net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout141 net67 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2077__A1 net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2250_ _0600_ net62 VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__nand2_1
XANTENNA__1481__B _0437_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_18_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2181_ _0622_ _0623_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_76_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2593__A _1260_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1965_ _0809_ _0812_ _0804_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1896_ _0808_ _0809_ _0804_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2517_ _1258_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__inv_2
X_2448_ ssdc.clk_divider\[18\] _1245_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__or2_1
XFILLER_0_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1391__B _0415_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2379_ _1192_ _1197_ _1198_ _1202_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_75_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1847__A net85 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2298__A1 _1047_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_4_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1750_ _0542_ _0678_ _0395_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_25_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1681_ _0393_ _0615_ net74 VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__o21a_1
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1981__A0 net82 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2302_ net280 _1059_ _1151_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__mux2_1
XANTENNA__2100__B net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2233_ _0606_ _1114_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__nand2_1
X_2164_ net62 _0683_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_36_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2095_ _0939_ _0946_ _0848_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2262__S _0483_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2213__A1 _0631_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_9_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1948_ net185 _0834_ _0857_ net196 VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__a31o_1
XFILLER_0_71_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1879_ _0514_ _0791_ _0792_ _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__or4_1
XFILLER_0_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2204__A1 _1091_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1802_ net82 _0723_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__xnor2_1
X_2782_ clknet_4_9_0_clk _0175_ _0013_ VGND VGND VPWR VPWR rf.registers\[10\]\[23\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1733_ _0395_ net97 _0557_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__or3_2
XFILLER_0_25_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1664_ net94 _0573_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__xor2_1
X_1595_ _0540_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1950__A _0490_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2216_ _0667_ _1067_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__nor2_1
XANTENNA__2357__S1 ssdc.digit_select\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2257__S _0483_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2147_ net288 _1041_ _1016_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__mux2_1
X_2078_ net326 _0979_ net139 VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1844__B net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1380_ net240 _0404_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__and2_1
X_2001_ _0546_ _0779_ _0630_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_26_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2765_ clknet_4_2_0_clk _0343_ _0159_ VGND VGND VPWR VPWR rf.registers\[10\]\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA__1945__A _0840_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2696_ clknet_4_0_0_clk _0274_ _0090_ VGND VGND VPWR VPWR rf.registers\[25\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_1716_ rf.registers\[25\]\[10\] _0472_ _0480_ rf.registers\[10\]\[10\] VGND VGND
+ VPWR VPWR _0648_ sky130_fd_sc_hd__a22o_1
X_1647_ net183 net189 _0578_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__or3_1
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1578_ rf.registers\[15\]\[4\] _0477_ _0487_ rf.registers\[5\]\[4\] VGND VGND VPWR
+ VPWR _0525_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2550_ _1263_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__inv_2
Xoutput107 net107 VGND VGND VPWR VPWR rd2_tb[16] sky130_fd_sc_hd__buf_2
XFILLER_0_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1501_ net141 net142 net1 net66 VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__and4bb_1
Xoutput129 net129 VGND VGND VPWR VPWR rd2_tb[7] sky130_fd_sc_hd__buf_2
Xoutput118 net118 VGND VGND VPWR VPWR rd2_tb[26] sky130_fd_sc_hd__buf_2
X_2481_ _1253_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1432_ net267 _0438_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__and2_1
X_1363_ _0402_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
X_1294_ net270 _0356_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2817_ clknet_4_6_0_clk _0210_ _0048_ VGND VGND VPWR VPWR rf.registers\[5\]\[23\]
+ sky130_fd_sc_hd__dfrtp_1
X_2748_ clknet_4_5_0_clk _0326_ _0142_ VGND VGND VPWR VPWR rf.registers\[15\]\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2679_ clknet_4_13_0_clk _0257_ _0073_ VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_57_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1585__A net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1479__B _0437_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1981_ net82 net81 _0804_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2602_ _1269_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__inv_2
X_2533_ _1261_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2464_ _1250_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__buf_4
XFILLER_0_48_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2395_ _1209_ _1210_ _1211_ _1212_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__or4_1
X_1415_ _0430_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1346_ _0389_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
X_1277_ _0352_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_62_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1389__B _0415_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout142 net65 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_2
XFILLER_0_49_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2180_ _1062_ _1070_ _0628_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__a21o_1
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1964_ net111 _0868_ _0870_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_83_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1895_ net69 _0798_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2516_ _1258_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__inv_2
X_2447_ ssdc.clk_divider\[18\] _1245_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2378_ _1193_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__inv_2
X_1329_ _0381_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_39_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_73_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1680_ _0394_ net74 _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__nor3_1
XANTENNA__1981__A1 net81 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output97_A net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2704__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2301_ _1160_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2100__C net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2232_ _0570_ _0575_ _0602_ _0604_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__a31o_1
X_2163_ _0682_ _0664_ _0676_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_36_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2094_ _0948_ _0945_ net122 VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1947_ net91 net88 net92 net89 net192 _0800_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__mux4_1
XFILLER_0_71_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1878_ net119 net117 net116 net115 VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__or4_1
XFILLER_0_31_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1858__A net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1487__B _0437_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1801_ _0542_ _0722_ _0395_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_38_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2781_ clknet_4_9_0_clk _0174_ _0012_ VGND VGND VPWR VPWR rf.registers\[10\]\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1732_ _0660_ _0637_ _0651_ _0624_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__or4_4
XFILLER_0_25_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2599__A _1268_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1663_ _0588_ _0598_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__a21o_1
XANTENNA__1954__A1 _0790_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1594_ _0537_ _0539_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2215_ _1100_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2131__A1 _0787_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2146_ _0787_ _1038_ _1040_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_88_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2077_ net62 _0957_ _0969_ _0978_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__a31o_1
XFILLER_0_88_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2273__S _1144_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1397__B _0415_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_15_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_55_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2000_ _0860_ _0526_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__nor2_2
XFILLER_0_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2764_ clknet_4_2_0_clk _0342_ _0158_ VGND VGND VPWR VPWR rf.registers\[10\]\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_26_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1715_ _0646_ _0645_ _0555_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_53_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2695_ clknet_4_0_0_clk _0273_ _0089_ VGND VGND VPWR VPWR rf.registers\[25\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1646_ _0518_ _0520_ _0517_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1577_ _0524_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_1
XFILLER_0_67_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1680__B net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2268__S _0483_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer10 net191 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_1
X_2129_ _0918_ _0926_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_80_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1615__B1 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_52_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1854__B1 _0483_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_15_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput108 net108 VGND VGND VPWR VPWR rd2_tb[17] sky130_fd_sc_hd__buf_2
Xoutput119 net119 VGND VGND VPWR VPWR rd2_tb[27] sky130_fd_sc_hd__buf_2
XFILLER_0_23_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2480_ _1253_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__inv_2
X_1500_ _0474_ VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_1
XFILLER_0_50_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1431_ _0437_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__buf_2
XANTENNA__2877__A net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1362_ _0354_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__or2_1
Xoutput90 net90 VGND VGND VPWR VPWR rd1_tb[2] sky130_fd_sc_hd__buf_2
X_1293_ _0362_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2117__A _0483_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2816_ clknet_4_5_0_clk _0209_ _0047_ VGND VGND VPWR VPWR rf.registers\[5\]\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1956__A _0483_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2022__A0 net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2747_ clknet_4_5_0_clk _0325_ _0141_ VGND VGND VPWR VPWR rf.registers\[15\]\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2678_ clknet_4_13_0_clk _0256_ _0072_ VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1629_ rf.registers\[25\]\[4\] _0473_ _0480_ rf.registers\[10\]\[4\] VGND VGND VPWR
+ VPWR _0571_ sky130_fd_sc_hd__a22o_1
XANTENNA__2325__A1 _1122_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1691__A net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1980_ _0834_ _0886_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer1 _0516_ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dlygate4sd1_1
X_2601_ _1269_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__inv_2
X_2532_ _1261_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__inv_2
X_2463_ _1251_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__inv_2
XANTENNA__2307__A1 _1081_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2394_ ssdc.clk_divider\[11\] ssdc.clk_divider\[10\] ssdc.clk_divider\[9\] ssdc.clk_divider\[8\]
+ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__or4bb_1
X_1414_ net333 _0426_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1345_ rf.registers\[5\]\[0\] _0355_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1530__A2 _0480_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1276_ ssdc.digit_select\[0\] ssdc.digit_select\[1\] VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__2281__S _1144_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1963_ _0840_ _0869_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1894_ net70 _0796_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2515_ _1258_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__inv_2
X_2446_ _1245_ net211 VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2377_ _1186_ _1193_ _1200_ _1201_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__a31o_1
XFILLER_0_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1328_ net301 _0378_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_39_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_output2_A net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1773__B net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2300_ net234 _1053_ _1151_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__mux2_1
X_2231_ _1113_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2162_ _1054_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__2096__S net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2093_ _0993_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_36_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1946_ _0851_ _0854_ _0855_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__mux2_1
X_1877_ net121 net113 net112 net124 VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__or4_1
XFILLER_0_71_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2429_ net225 _1233_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__xor2_1
XFILLER_0_39_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1858__B net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_81_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1800_ net114 _0529_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2780_ clknet_4_14_0_clk _0173_ _0011_ VGND VGND VPWR VPWR rf.registers\[10\]\[21\]
+ sky130_fd_sc_hd__dfrtp_1
X_1731_ _0655_ _0659_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__nand2_1
X_1662_ net93 _0581_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__xor2_1
X_1593_ _0538_ _0397_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__nand2_2
XFILLER_0_21_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2214_ net285 _1099_ _1087_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2145_ _1025_ _0963_ _1012_ _0961_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__o221a_1
XFILLER_0_56_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2076_ _0867_ _0972_ _0974_ _0975_ _0977_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__a221o_1
XFILLER_0_88_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1929_ _0836_ _0839_ _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold90 rf.registers\[25\]\[29\] VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_58_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2763_ clknet_4_2_0_clk _0341_ _0157_ VGND VGND VPWR VPWR rf.registers\[10\]\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_60_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1714_ net131 _0640_ net101 VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_53_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2694_ clknet_4_13_0_clk _0272_ _0088_ VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__dfrtp_2
X_1645_ _0584_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__clkbuf_2
X_1576_ rf.registers\[15\]\[5\] _0477_ _0487_ rf.registers\[5\]\[5\] VGND VGND VPWR
+ VPWR _0524_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer11 net189 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2128_ _0932_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_80_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2059_ _0807_ _0846_ _0848_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_52_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput109 net109 VGND VGND VPWR VPWR rd2_tb[18] sky130_fd_sc_hd__buf_2
XFILLER_0_23_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1430_ _0397_ _0398_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__nand2_4
XFILLER_0_50_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1361_ _0400_ net142 VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__and2b_1
Xoutput80 net80 VGND VGND VPWR VPWR rd1_tb[20] sky130_fd_sc_hd__buf_2
Xoutput91 net91 VGND VGND VPWR VPWR rd1_tb[30] sky130_fd_sc_hd__buf_2
X_1292_ net273 _0356_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__and2_1
XFILLER_0_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1302__A _0355_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_85_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2815_ clknet_4_5_0_clk _0208_ _0046_ VGND VGND VPWR VPWR rf.registers\[5\]\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_73_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2746_ clknet_4_5_0_clk _0324_ _0140_ VGND VGND VPWR VPWR rf.registers\[15\]\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2022__A1 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2677_ clknet_4_13_0_clk _0255_ _0071_ VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1628_ _0395_ _0568_ net95 VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__o21ai_2
XANTENNA__2279__S _1144_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1559_ _0510_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_57_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2261__B2 _0631_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1882__A net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2252__A1 _1130_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer2 net183 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlygate4sd1_1
X_2600_ _1269_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2531_ _1261_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2462_ _1251_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__inv_2
X_2393_ ssdc.clk_divider\[13\] ssdc.clk_divider\[12\] ssdc.clk_divider\[15\] ssdc.clk_divider\[14\]
+ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__or4bb_1
X_1413_ _0429_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1344_ net141 _0354_ net230 VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__a21o_1
XFILLER_0_64_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1967__A _0840_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_46_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2729_ clknet_4_1_0_clk _0307_ _0123_ VGND VGND VPWR VPWR rf.registers\[15\]\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1877__A net121 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_37_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2225__A1 _1108_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1962_ _0803_ _0808_ _0804_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1893_ _0801_ _0805_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2514_ _1258_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__inv_2
X_2445_ ssdc.clk_divider\[16\] _1242_ net210 VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2376_ _1186_ _1183_ _1200_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__nor3_1
X_1327_ _0380_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_39_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__1697__A _0630_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1718__B1 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_52_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2230_ net282 _1112_ _1087_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__mux2_1
X_2161_ net252 _1053_ _1016_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__mux2_1
X_2092_ net290 _0992_ net52 VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1945_ _0840_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__buf_2
XFILLER_0_83_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1876_ net123 net120 net118 net114 VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__or4_1
XFILLER_0_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2428_ _1233_ net215 VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__nor2_1
X_2359_ net24 net30 net3 net7 ssdc.digit_select\[0\] ssdc.digit_select\[1\] VGND VGND
+ VPWR VPWR _1187_ sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_70_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1874__B _0490_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2373__B1 _1183_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1890__A _0578_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_8_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2773__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1730_ net98 _0658_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__xor2_1
XFILLER_0_53_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1661_ _0592_ _0596_ _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__o21ai_1
X_1592_ net141 VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__inv_2
X_2213_ _0631_ _1069_ _1098_ _0907_ _0972_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__a32o_1
XFILLER_0_56_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2144_ _0926_ _0960_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_49_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2075_ _0848_ _0899_ _0976_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_76_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1928_ _0518_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__buf_2
XFILLER_0_71_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1859_ net60 _0774_ net89 VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__o21a_1
XFILLER_0_12_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2346__B1 _0490_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold91 rf.registers\[5\]\[26\] VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__dlygate4sd3_1
Xhold80 rf.registers\[10\]\[4\] VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_18_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2669__CLK clknet_4_7_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2831_ clknet_4_11_0_clk _0220_ VGND VGND VPWR VPWR ssdc.digit_select\[1\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_26_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2762_ clknet_4_0_0_clk _0340_ _0156_ VGND VGND VPWR VPWR rf.registers\[10\]\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1713_ net101 net131 _0640_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__or3_4
XFILLER_0_41_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2693_ clknet_4_13_0_clk _0271_ _0087_ VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__dfrtp_2
XANTENNA__2337__B1 _1144_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1644_ rf.registers\[25\]\[2\] _0472_ _0478_ rf.registers\[10\]\[2\] VGND VGND VPWR
+ VPWR _0584_ sky130_fd_sc_hd__a22o_1
X_1575_ _0522_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__buf_6
Xrebuffer12 net193 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_1_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2127_ _0714_ _1006_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__xnor2_1
X_2058_ _0960_ _0961_ _0832_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_80_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__1854__A2 net140 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput2 net2 VGND VGND VPWR VPWR Result[0] sky130_fd_sc_hd__buf_2
XFILLER_0_50_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput70 net70 VGND VGND VPWR VPWR rd1_tb[11] sky130_fd_sc_hd__buf_2
X_1360_ net1 VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__buf_4
XANTENNA_output65_A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput81 net81 VGND VGND VPWR VPWR rd1_tb[21] sky130_fd_sc_hd__buf_2
Xoutput92 net92 VGND VGND VPWR VPWR rd1_tb[31] sky130_fd_sc_hd__buf_2
X_1291_ _0361_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2814_ clknet_4_4_0_clk _0207_ _0045_ VGND VGND VPWR VPWR rf.registers\[5\]\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_73_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2745_ clknet_4_4_0_clk _0323_ _0139_ VGND VGND VPWR VPWR rf.registers\[15\]\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_78_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2676_ clknet_4_13_0_clk _0254_ _0070_ VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1627_ _0569_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__clkbuf_2
X_1558_ rf.registers\[15\]\[12\] _0477_ _0487_ rf.registers\[5\]\[12\] VGND VGND VPWR
+ VPWR _0510_ sky130_fd_sc_hd__a22o_1
X_1489_ net337 _0399_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_57_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer3 net184 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA__2707__CLK clknet_4_3_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2530_ _1261_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2461_ _1251_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__inv_2
X_1412_ net336 _0426_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__and2_1
X_2392_ ssdc.clk_divider\[17\] ssdc.clk_divider\[16\] ssdc.clk_divider\[19\] ssdc.clk_divider\[18\]
+ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__or4_1
X_1343_ _0388_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2728_ clknet_4_0_0_clk _0306_ _0122_ VGND VGND VPWR VPWR rf.registers\[15\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_2659_ clknet_4_10_0_clk _0237_ VGND VGND VPWR VPWR ssdc.clk_divider\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1690__B1 _0480_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_64_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_76_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1681__B1 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1961_ _0797_ _0802_ net100 VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__mux2_1
X_1892_ net191 VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2513_ _1258_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__inv_2
X_2444_ ssdc.clk_divider\[17\] ssdc.clk_divider\[16\] _1242_ VGND VGND VPWR VPWR _1245_
+ sky130_fd_sc_hd__and3_1
X_2375_ _1182_ _1187_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__xnor2_1
X_1326_ net235 _0378_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__and2_1
XANTENNA__2161__A1 _1053_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_66_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__1917__S _0815_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_73_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2160_ _0975_ _0984_ _1051_ _1052_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__a211o_1
X_2091_ _0787_ _0982_ _0991_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_36_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1944_ _0852_ _0853_ _0800_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1875_ net127 _0789_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__or2_4
XFILLER_0_43_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_4_6_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2382__A1 _1183_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2427_ ssdc.clk_divider\[10\] _1230_ net214 VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2358_ _1185_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__clkbuf_2
X_1309_ rf.registers\[5\]\[18\] _0367_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__and2_1
X_2289_ _1154_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_70_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2125__A1 _1022_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1660_ net90 _0587_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__xor2_1
X_1591_ _0354_ _0392_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__nand2_1
XANTENNA_output95_A net95 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2212_ _1064_ _1068_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__nand2_1
X_2143_ _0689_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_49_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2074_ net122 _0890_ _0932_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__a21o_1
XFILLER_0_72_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1927_ _0837_ _0838_ net100 VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1858_ net60 net89 _0774_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__nor3_1
XFILLER_0_31_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1789_ _0396_ _0711_ net81 VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_4_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1866__B1 _0490_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_79_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold81 rf.registers\[15\]\[16\] VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__dlygate4sd3_1
Xhold92 rf.registers\[15\]\[23\] VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__dlygate4sd3_1
Xhold70 rf.registers\[25\]\[17\] VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_11_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2830_ clknet_4_11_0_clk _0219_ VGND VGND VPWR VPWR ssdc.digit_select\[0\] sky130_fd_sc_hd__dfxtp_4
XFILLER_0_73_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2761_ clknet_4_0_0_clk _0339_ _0155_ VGND VGND VPWR VPWR rf.registers\[10\]\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_26_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1712_ _0393_ _0642_ net70 VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__o21a_1
XFILLER_0_26_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2692_ clknet_4_13_0_clk _0270_ _0086_ VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dfrtp_1
X_1643_ net93 _0582_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__nand2_1
XANTENNA__2337__A1 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1574_ _0515_ _0517_ _0519_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__or4_4
XANTENNA__1560__A2 _0478_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer13 _0515_ VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dlygate4sd1_1
X_2126_ _1023_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__clkbuf_1
X_2057_ _0876_ _0830_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_80_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2273__A0 net25 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_52_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_4_14_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2319__A1 _1108_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput3 net3 VGND VGND VPWR VPWR Result[10] sky130_fd_sc_hd__buf_2
Xoutput60 net60 VGND VGND VPWR VPWR instruction_tb[29] sky130_fd_sc_hd__buf_2
Xoutput93 net93 VGND VGND VPWR VPWR rd1_tb[3] sky130_fd_sc_hd__buf_2
Xoutput71 net71 VGND VGND VPWR VPWR rd1_tb[12] sky130_fd_sc_hd__buf_2
Xoutput82 net82 VGND VGND VPWR VPWR rd1_tb[22] sky130_fd_sc_hd__buf_2
X_1290_ net314 _0356_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__and2_1
XFILLER_0_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2813_ clknet_4_5_0_clk _0206_ _0044_ VGND VGND VPWR VPWR rf.registers\[5\]\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2744_ clknet_4_4_0_clk _0322_ _0138_ VGND VGND VPWR VPWR rf.registers\[15\]\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2675_ clknet_4_7_0_clk _0253_ _0069_ VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_78_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1626_ rf.registers\[25\]\[5\] _0473_ _0480_ rf.registers\[10\]\[5\] VGND VGND VPWR
+ VPWR _0569_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1557_ _0509_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_22_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1488_ _0467_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_57_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2109_ _0724_ _0712_ _1007_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_65_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2340__A _0392_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_20_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__1524__A2 _0479_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__1403__B _0415_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2234__B _0787_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_63_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer4 net102 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__dlygate4sd1_1
X_2460_ _1251_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__inv_2
X_1411_ _0428_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__clkbuf_1
X_2391_ ssdc.clk_divider\[5\] ssdc.clk_divider\[7\] _1207_ _1208_ VGND VGND VPWR VPWR
+ _1209_ sky130_fd_sc_hd__or4_1
X_1342_ rf.registers\[5\]\[2\] _0378_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_79_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2228__B1 _0630_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_58_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2727_ clknet_4_0_0_clk _0305_ _0121_ VGND VGND VPWR VPWR rf.registers\[15\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2658_ clknet_4_10_0_clk _0236_ VGND VGND VPWR VPWR ssdc.clk_divider\[15\] sky130_fd_sc_hd__dfxtp_1
X_1609_ net128 _0523_ _0526_ net129 VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_10_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2589_ _1266_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input1_A control VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_69_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1681__A1 _0393_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1960_ net194 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_55_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1891_ _0802_ _0803_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2512_ _1258_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__inv_2
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2443_ net224 _1242_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__xor2_1
X_2374_ _1198_ _1199_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__nor2_1
X_1325_ _0379_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkbuf_1
XANTENNA_clkbuf_4_2_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_49_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_67_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2004__S net139 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_76_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2090_ _0790_ _0987_ _0988_ _0926_ _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__o221a_1
XFILLER_0_45_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_85_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1943_ net87 _0796_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1874_ rf.registers\[5\]\[4\] _0490_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2426_ ssdc.clk_divider\[11\] ssdc.clk_divider\[10\] _1230_ VGND VGND VPWR VPWR _1233_
+ sky130_fd_sc_hd__and3_1
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2357_ net13 net29 net33 net6 ssdc.digit_select\[0\] ssdc.digit_select\[1\] VGND
+ VGND VPWR VPWR _1185_ sky130_fd_sc_hd__mux4_2
XFILLER_0_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1308_ _0370_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_1
X_2288_ net17 _1015_ _1151_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_70_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2061__A1 net122 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_38_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1590_ _0534_ _0535_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__or2b_1
XFILLER_0_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_output88_A net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2211_ _1097_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__clkbuf_1
X_2142_ _0730_ _1036_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_49_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2073_ _0832_ _0907_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__and2_1
XANTENNA__1602__A net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1926_ _0578_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_44_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1857_ _0533_ _0773_ _0556_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_31_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1788_ _0395_ net81 _0711_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__or3_1
X_2409_ ssdc.clk_divider\[4\] _1218_ net216 VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_4_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2343__A _0577_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2346__A2 _1144_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_4_10_0_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold60 rf.registers\[5\]\[16\] VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlygate4sd3_1
Xhold82 rf.registers\[5\]\[12\] VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 rf.registers\[5\]\[31\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__dlygate4sd3_1
Xhold93 rf.registers\[15\]\[17\] VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2760_ clknet_4_0_0_clk _0338_ _0154_ VGND VGND VPWR VPWR rf.registers\[10\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_26_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
X_1711_ _0394_ net70 _0642_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__nor3_1
X_2691_ clknet_4_12_0_clk _0269_ _0085_ VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_1_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1642_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__inv_2
XFILLER_0_41_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__2337__A2 _0392_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1573_ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__inv_2
XFILLER_0_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer14 net195 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dlygate4sd1_1
X_2125_ net291 _1022_ _1016_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2056_ _0814_ _0823_ _0815_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1909_ _0819_ _0822_ _0806_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1507__A _0480_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_40_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__1941__S net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput4 net4 VGND VGND VPWR VPWR Result[11] sky130_fd_sc_hd__buf_2
Xoutput50 net50 VGND VGND VPWR VPWR instruction_tb[19] sky130_fd_sc_hd__buf_2
Xoutput61 net61 VGND VGND VPWR VPWR instruction_tb[2] sky130_fd_sc_hd__buf_2
Xoutput94 net94 VGND VGND VPWR VPWR rd1_tb[4] sky130_fd_sc_hd__buf_2
Xoutput72 net72 VGND VGND VPWR VPWR rd1_tb[13] sky130_fd_sc_hd__buf_2
Xoutput83 net83 VGND VGND VPWR VPWR rd1_tb[23] sky130_fd_sc_hd__buf_2
XFILLER_0_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2812_ clknet_4_5_0_clk _0205_ _0043_ VGND VGND VPWR VPWR rf.registers\[5\]\[18\]
+ sky130_fd_sc_hd__dfrtp_1
X_2743_ clknet_4_4_0_clk _0321_ _0137_ VGND VGND VPWR VPWR rf.registers\[15\]\[16\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2674_ clknet_4_7_0_clk _0252_ _0068_ VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1625_ _0562_ _0567_ _0541_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__o21a_1
X_1556_ rf.registers\[15\]\[14\] _0477_ _0487_ rf.registers\[5\]\[14\] VGND VGND VPWR
+ VPWR _0509_ sky130_fd_sc_hd__a22o_1
X_1487_ net298 _0437_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_57_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2108_ _0713_ _1006_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_65_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2246__A1 _1025_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2039_ _0941_ _0943_ _0832_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__mux2_2
XFILLER_0_76_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer5 net102 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_23_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2531__A _1261_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2250__B net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1410_ net265 _0426_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__and2_1
X_2390_ ssdc.clk_divider\[0\] ssdc.clk_divider\[1\] ssdc.clk_divider\[3\] ssdc.clk_divider\[2\]
+ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__or4_1
XANTENNA_output70_A net70 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1341_ _0387_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2726_ clknet_4_15_0_clk _0304_ _0120_ VGND VGND VPWR VPWR rf.registers\[25\]\[31\]
+ sky130_fd_sc_hd__dfrtp_1
X_2657_ clknet_4_10_0_clk _0235_ VGND VGND VPWR VPWR ssdc.clk_divider\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1608_ _0552_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__inv_2
X_2588_ _1266_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1539_ _0500_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_69_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__2219__A1 _1103_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2526__A rst VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2245__B net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ _0578_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2511_ _1258_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__inv_2
X_2442_ _1244_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__clkbuf_1
X_2373_ _1182_ _1187_ _1183_ _1189_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1324_ net247 _0378_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_39_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2709_ clknet_4_3_0_clk _0287_ _0103_ VGND VGND VPWR VPWR rf.registers\[25\]\[14\]
+ sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1942_ net86 _0796_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1873_ _0780_ _0785_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2425_ net226 _1230_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__xor2_1
X_2356_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__inv_2
XFILLER_0_19_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1307_ net318 _0367_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__and2_1
X_2287_ _1153_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1501__C net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2015__S _0815_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_80_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2210_ net246 _1096_ _1087_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__mux2_1
X_2141_ _0694_ _0699_ _1035_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_49_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2072_ _0871_ _0973_ net185 VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1925_ net82 _0796_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1856_ net120 _0532_ net121 VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_44_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1787_ _0529_ _0710_ _0556_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2408_ ssdc.clk_divider\[5\] ssdc.clk_divider\[4\] _1218_ VGND VGND VPWR VPWR _1221_
+ sky130_fd_sc_hd__and3_1
X_2339_ _0787_ VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_4_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1866__A2 _0479_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1512__B net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2343__B _0860_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold50 rf.registers\[10\]\[17\] VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 rf.registers\[5\]\[23\] VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold83 rf.registers\[10\]\[10\] VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 rf.registers\[10\]\[22\] VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlygate4sd3_1
Xhold94 rf.registers\[15\]\[5\] VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2534__A _1261_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1710_ _0639_ _0641_ _0541_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__o21a_1
X_2690_ clknet_4_12_0_clk _0268_ _0084_ VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__dfrtp_1
X_1641_ _0577_ _0539_ _0580_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__and3_1
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1572_ rf.registers\[15\]\[0\] _0476_ _0486_ rf.registers\[5\]\[0\] VGND VGND VPWR
+ VPWR _0520_ sky130_fd_sc_hd__a22oi_4
X_2124_ net62 _1008_ _1018_ _1021_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__a31o_1
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer15 net196 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dlygate4sd3_1
X_2055_ _0748_ _0957_ _0744_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1908_ _0820_ _0821_ _0578_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1839_ net116 _0715_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2354__A _1181_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput5 net5 VGND VGND VPWR VPWR Result[12] sky130_fd_sc_hd__buf_2
Xoutput40 net40 VGND VGND VPWR VPWR an[3] sky130_fd_sc_hd__clkbuf_4
Xoutput51 net51 VGND VGND VPWR VPWR instruction_tb[1] sky130_fd_sc_hd__buf_2
Xoutput62 net62 VGND VGND VPWR VPWR instruction_tb[30] sky130_fd_sc_hd__buf_2
Xoutput73 net73 VGND VGND VPWR VPWR rd1_tb[14] sky130_fd_sc_hd__buf_2
Xoutput84 net84 VGND VGND VPWR VPWR rd1_tb[24] sky130_fd_sc_hd__buf_2
XFILLER_0_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput95 net95 VGND VGND VPWR VPWR rd1_tb[5] sky130_fd_sc_hd__buf_2
XANTENNA__2529__A _1261_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2811_ clknet_4_4_0_clk _0204_ _0042_ VGND VGND VPWR VPWR rf.registers\[5\]\[17\]
+ sky130_fd_sc_hd__dfrtp_1
X_2742_ clknet_4_4_0_clk _0320_ _0136_ VGND VGND VPWR VPWR rf.registers\[15\]\[15\]
+ sky130_fd_sc_hd__dfrtp_1
X_2673_ clknet_4_7_0_clk _0251_ _0067_ VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1624_ net126 _0523_ net127 VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__o21a_1
XFILLER_0_41_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1555_ _0508_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__buf_1
XFILLER_0_1_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__2191__B2 net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1486_ _0466_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2107_ _0708_ _1005_ _0706_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_65_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2038_ _0586_ _0828_ _0942_ _0876_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__o22a_2
XFILLER_0_76_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
X_2871__182 VGND VGND VPWR VPWR _2871__182/HI net182 sky130_fd_sc_hd__conb_1
XFILLER_0_87_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__1693__B1 _0393_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_28_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer6 _0476_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dlymetal6s2s_1
X_1340_ rf.registers\[5\]\[3\] _0378_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2725_ clknet_4_15_0_clk _0303_ _0119_ VGND VGND VPWR VPWR rf.registers\[25\]\[30\]
+ sky130_fd_sc_hd__dfrtp_1
X_2656_ clknet_4_10_0_clk _0234_ VGND VGND VPWR VPWR ssdc.clk_divider\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1607_ _0550_ _0551_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2587_ _1266_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__inv_2
XFILLER_0_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1538_ rf.registers\[15\]\[10\] net188 _0486_ rf.registers\[5\]\[10\] VGND VGND VPWR
+ VPWR _0500_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1469_ net239 _0449_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_25_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2510_ _1258_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__inv_2
X_2441_ _1214_ _1241_ _1243_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__and3_1
XFILLER_0_59_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2146__A1 _0787_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2372_ _1182_ _1186_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__and2b_1
X_1323_ _0355_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_39_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2452__A rst VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2708_ clknet_4_3_0_clk _0286_ _0102_ VGND VGND VPWR VPWR rf.registers\[25\]\[13\]
+ sky130_fd_sc_hd__dfrtp_1
X_2639_ _1205_ ssdc.digit_select\[0\] _1214_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__2137__A1 _0787_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_10_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2537__A _1261_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__2300__A1 _1053_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_output26_A net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1941_ _0849_ _0850_ net100 VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1872_ _0630_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_9_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2424_ _1232_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2355_ net27 net31 net4 net8 ssdc.digit_select\[0\] ssdc.digit_select\[1\] VGND VGND
+ VPWR VPWR _1183_ sky130_fd_sc_hd__mux4_2
X_1306_ _0369_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2286_ net18 _1003_ _1151_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__mux2_1
XANTENNA__1351__A _0393_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__1869__B1 net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2140_ _0683_ _0728_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__nand2_1
X_2071_ _0895_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_49_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1924_ net83 _0796_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1855_ _0772_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__buf_2
X_1786_ net112 _0512_ _0528_ net113 VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__o31ai_1
X_2407_ net223 _1218_ _1220_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2338_ net142 _0392_ _1144_ VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__o21a_1
X_2269_ _1143_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__clkbuf_1
XANTENNA__1512__C net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold40 ssdc.clk_divider\[3\] VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 rf.registers\[5\]\[20\] VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 rf.registers\[5\]\[7\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 rf.registers\[10\]\[18\] VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlygate4sd3_1
Xhold95 rf.registers\[25\]\[31\] VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold84 rf.registers\[10\]\[21\] VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1640_ _0523_ _0579_ _0555_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__a21o_1
X_1571_ _0518_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__inv_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__2387__B_N ssdc.digit_select\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2123_ _0877_ _0975_ _1019_ _0884_ _1020_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__a221o_1
XFILLER_0_88_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2054_ _0744_ _0748_ _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__and3_1
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__2353__S0 ssdc.digit_select\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1907_ net94 _0795_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1838_ _0755_ _0756_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__and2_1
XANTENNA__1784__A2 _0474_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_4_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__1536__A2 _0478_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1769_ rf.registers\[25\]\[17\] _0474_ _0481_ rf.registers\[10\]\[17\] VGND VGND
+ VPWR VPWR _0696_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput6 net6 VGND VGND VPWR VPWR Result[13] sky130_fd_sc_hd__buf_2
Xoutput52 net139 VGND VGND VPWR VPWR instruction_tb[20] sky130_fd_sc_hd__buf_2
Xoutput41 net41 VGND VGND VPWR VPWR immediate_tb[0] sky130_fd_sc_hd__buf_2
Xoutput30 net30 VGND VGND VPWR VPWR Result[6] sky130_fd_sc_hd__buf_2
XFILLER_0_31_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput63 net63 VGND VGND VPWR VPWR instruction_tb[31] sky130_fd_sc_hd__buf_2
Xoutput74 net74 VGND VGND VPWR VPWR rd1_tb[15] sky130_fd_sc_hd__buf_2
Xoutput85 net85 VGND VGND VPWR VPWR rd1_tb[25] sky130_fd_sc_hd__buf_2
Xoutput96 net96 VGND VGND VPWR VPWR rd1_tb[6] sky130_fd_sc_hd__buf_2
XFILLER_0_37_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2810_ clknet_4_4_0_clk _0203_ _0041_ VGND VGND VPWR VPWR rf.registers\[5\]\[16\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_26_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2741_ clknet_4_5_0_clk _0319_ _0135_ VGND VGND VPWR VPWR rf.registers\[15\]\[14\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_81_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2672_ clknet_4_7_0_clk _0250_ _0066_ VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1623_ _0565_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__inv_2
X_1554_ rf.registers\[15\]\[13\] _0477_ _0487_ rf.registers\[5\]\[13\] VGND VGND VPWR
+ VPWR _0508_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1485_ net276 _0437_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__and2_1
.ends
